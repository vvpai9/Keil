# Keil uVision project signum-m3-demo.uvproj, settings and files
target Demo_20000000 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Demo_20000000
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\Demo_20000000.sct
  group Sources
    ./: init.s led.c demo.c delayfun.c
  group Scatter Files
    ./: Demo_20000000.sct Demo_08000000.sct Demo_0.sct Demo_0_20000000.sct Demo_0_08000000.sct Demo_08000000_20000000.sct
target Demo_08000000 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Demo_08000000
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\Demo_08000000.sct
target Demo_0 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Demo_0
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\Demo_0.sct
target Demo_0_20000000 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Demo_0_20000000
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Demo_0_20000000.sct
target Demo_0_08000000 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Demo_0_08000000
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Demo_0_08000000.sct
target Demo_08000000_20000000 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Demo_08000000_20000000
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Demo_08000000_20000000.sct
