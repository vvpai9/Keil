# Keil uVision project RTX_Lib_ARM.uvproj, settings and files
target ARM_LE (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: RTX_ARM_L (library)
  c flags: Optim=4 OneElfS=1
  group Kernel
    ./SRC/ARM/: rt_System.c rt_Task.c rt_List.c rt_Time.c rt_Event.c rt_Mailbox.c rt_Semaphore.c rt_Mutex.c rt_Timer.c rt_Robin.c rt_MemBox.c
  group Config
    ./SRC/ARM/: SWI_Table.s HAL_ARM.c HAL_CR4.c HAL_ARM9F.c
target ARM_LE_A (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: RTX_ARM_LA (library)
  c flags: Optim=4 OneElfS=1
target ARM_BE (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: RTX_ARM_B (library)
  c flags: Optim=4 OneElfS=1
target ARM_BE_A (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: RTX_ARM_BA (library)
  c flags: Optim=4 OneElfS=1
target ARM9F_LE (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: RTX_ARM9F_L (library)
  c flags: Optim=4 OneElfS=1
  c misc: --fpu=vfpv2
target ARM9F_LE_A (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: RTX_ARM9F_LA (library)
  c flags: Optim=4 OneElfS=1
  c misc: --fpu=vfpv2
target ARM9F_BE (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: RTX_ARM9F_B (library)
  c flags: Optim=4 OneElfS=1
  c misc: --fpu=vfpv2
target ARM9F_BE_A (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: RTX_ARM9F_BA (library)
  c flags: Optim=4 OneElfS=1
  c misc: --fpu=vfpv2
target CR4F_LE (ARM-ADS)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: RTX_CR4F_L (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
target CR4F_LE_A (ARM-ADS)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: RTX_CR4F_LA (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
target CR4F_BE (ARM-ADS)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: RTX_CR4F_B (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
target CR4F_BE_A (ARM-ADS)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: RTX_CR4F_BA (library)
  c flags: Optim=4 OneElfS=1
  c misc: --diag_suppress=1786
target CR4_LE (ARM-ADS)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: RTX_CR4_L (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
target CR4_LE_A (ARM-ADS)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: RTX_CR4_LA (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
target CR4_BE (ARM-ADS)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: RTX_CR4_B (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
target CR4_BE_A (ARM-ADS)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: RTX_CR4_BA (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --diag_suppress=1786
