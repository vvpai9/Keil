# Keil uVision project Hello.uvproj, settings and files
target RMS100 LH75401 Flash (ARM-ADS)
  device: LH75401 Sharp
  cpu: IRAM(0x60000000-0x60003FFF) XRAM(0x80000000-0x80003FFF) CLOCK(14745600) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x40000000 size 0x400000
  memory RVCT6: RAM 0x44000000 size 0x80000
  memory RVCT9: RAM 0x60000000 size 0x4000
  memory RVCT10: RAM 0x80000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c Time.c
  group Source Code
    ./: Hello.c
  group Documentation
    ./: Abstract.txt
target RMS100 LH75401 RAM (ARM-ADS)
  device: LH75401 Sharp
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x40000000 size 0x400000
  memory RVCT5: ROM 0x80000000 size 0x2000
  memory RVCT6: RAM 0x44000000 size 0x80000
  memory RVCT9: RAM 0x60000000 size 0x4000
  memory RVCT10: RAM 0x80002000 size 0x2000
