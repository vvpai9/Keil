# Keil uVision project Telnet_demo.uvproj, settings and files
target MCB2470 (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c LPC2400.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: EMAC_LPC2470.c
  group Documentation
    ./: Abstract.txt
target MCB2470 Debug (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
