# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2400.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Blinky.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LPC2478 Flash (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
target LPC2478 Ext SDRAM (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000040 size 0x17fc0
  memory RVCT10: RAM 0x7fe00000 size 0x4000
target LPC2478 Ext NOR Flash (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40017FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  asm define: NO_EMC_SETUP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x400000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x18000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
