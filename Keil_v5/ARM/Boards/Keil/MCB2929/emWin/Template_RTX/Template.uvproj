# Keil uVision project Template.uvproj, settings and files
target MCB2929 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2929 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000DFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xe000
  group Startup
    ./: LPC29xx.s
  group RTX Configuration
    ./: RTX_Config.c
  group LCD Driver
    ./: LCDConf.c LCD_X_16BitIF_LPC2900.c
  group GUI Library
    ./: GUIConf.c GUI_X_RTX.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_ARM_L.lib
  group Source Code
    ./: main.c
  group Documentation
    ./: Abstract.txt
