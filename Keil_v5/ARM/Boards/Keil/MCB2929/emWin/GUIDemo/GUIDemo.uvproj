# Keil uVision project GUIDemo.uvproj, settings and files
target MCB2929 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2929 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000DFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: GUIDemo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: GUI_BYTESPERPIXEL=4 SHOW_GUIDEMO_AUTOMOTIVE SHOW_GUIDEMO_COLORBAR SHOW_GUIDEMO_CURSOR  SHOW_GUIDEMO_GRAPH SHOW_GUIDEMO_ICONVIEW SHOW_GUIDEMO_SPEED SHOW_GUIDEMO_TRANSPARENTDIALOG SHOW_GUIDEMO_TREEVIEW
  c include: C:\Keil\ARM\Segger\emWin\Include
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xe000
  group Startup
    ./: LPC29xx.s
  group Drivers
    ./: LCDConf.c LCD_X_16BitIF_LPC2900.c JOY.c
  group GUI Library
    ./: GUIConf.c GUI_X.c
    C:/Keil/ARM/Segger/emWin/Lib/: GUI_ARM_L.lib
  group Source Code
    ./: main.c
    C:/Keil/ARM/Segger/emWin/Sample/Application/GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c
