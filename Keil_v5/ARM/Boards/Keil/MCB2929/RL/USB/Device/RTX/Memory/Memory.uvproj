# Keil uVision project Memory.uvproj, settings and files
target MCB2900 RTX (ARM-ADS)
  device: LPC2929 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000DFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: Memory
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xe000
  group Startup Code
    ./: LPC29xx.s SWI_Table.s
  group configuration
    ./: usb_config.c RTX_Conf_LPC29xx.c
  group USB HW Driver
    ./: usbd_LPC29xx.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c GLCD_16bit_LPC2900.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
