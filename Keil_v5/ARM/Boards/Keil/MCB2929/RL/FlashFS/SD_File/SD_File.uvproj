# Keil uVision project SD_File.uvproj, settings and files
target MCB2929 (ARM-ADS)
  device: LPC2929 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000DFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: SD_File
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xe000
  group Source Files
    ./: SD_File.c Getline.c GLCD_16bit_LPC2900.c
  group Configuration Files
    ./: LPC29xx.s File_Config.c SPI_LPC29xx.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
