# Keil uVision project CAN_Ex1.uvproj, settings and files
target MCB2929 (ARM-ADS)
  device: LPC2929 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000DFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: CAN_Ex1
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xe000
  group Startup File
    ./: LPC29xx.s
  group Configuration
    ./: RTX_Config.c CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group Source
    ./: CAN_Ex1.c GLCD_16bit_LPC2900.c IRQ.c
  group CAN Driver
    ./: CAN_LPC29xx.c
  group Documentation
    ./: Abstract.txt
