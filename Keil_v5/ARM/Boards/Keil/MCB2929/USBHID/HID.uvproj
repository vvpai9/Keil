# Keil uVision project HID.uvproj, settings and files
target MCB2929 (ARM-ADS)
  device: LPC2929 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000DFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: HID
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xe000
  group Startup Files
    ./: LPC29xx.s
  group Source Files
    ./: usbcfg.h usbcore.c usbdesc.c usbhw.c usbuser.c hiduser.c demo.c GLCD_16bit_LPC2900.c
  group Documentation
    ./: Abstract.txt
