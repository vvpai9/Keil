# Keil uVision project Blinky.uvproj, settings and files
target MCBTMS570 (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: IRAM(0x08000000-0x08027FFF) IROM(0-0x001FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") EBIG
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  group Source
    ./: Blinky.c GLCD.c emif.c
  group Configuration
    ./: RTX_Config.c startup_TMS570LS.s system.c
  group Documentation
    ./: Abstract.txt
