# Keil uVision project Blinky.uvproj, settings and files
target TMS570 Flash (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: IRAM(0x08000000-0x08027FFF) IROM(0-0x001FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") EBIG
  output: Blinky
  c flags: Optim=1
  c include: ./
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  group Startup Files
    ./: startup_TMS570LS.s system.c
  group Source Files
    ./: Blinky.c GLCD.c adc.c gio.c Retarget.c Serial.c emif.c Timer.c IRQ.c NHET.c
  group Documentation
    ./: Abstract.txt
