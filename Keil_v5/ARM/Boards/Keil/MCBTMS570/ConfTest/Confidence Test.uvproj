# Keil uVision project Confidence Test.uvproj, settings and files
target TMS570 Flash (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: IRAM(0x08000000-0x08027FFF) IROM(0-0x001FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") EBIG
  output: Confidence Test
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  group Source Files
    ./Source/: ConfidenceTest.c GLCD.c SDCard.c adc.c EMIF_Config.c gio.c spi1.c spi3.c rti.c Serial.c NHET.c
  group Graphic Files
    ./Images/: Keil_Logo_16bpp.c TI_Logo_16bpp.c Button_TmpLight_16bpp.c Button_SDCard_16bpp.c Button_Memory_16bpp.c Button_Air_16bpp.c Button_Solenoid_16bpp.c Button_Sensors_16bpp.c Button_Pump_16bpp.c Button_Pump_sel_16bpp.c Button_Valve_16bpp.c Button_Valve_sel_16bpp.c Button_Relay_16bpp.c Button_Relay_sel_16bpp.c Button_Sol1_16bpp.c Button_Sol1_sel_16bpp.c Button_Sol2_16bpp.c Button_Sol2_sel_16bpp.c Button_Sol3_16bpp.c Button_Sol3_sel_16bpp.c Button_Sol4_16bpp.c Button_Sol4_sel_16bpp.c Button_OK_16bpp.c
  group Startup Files
    ./Source/: startup_TMS570LS.s R4_MPU_Config.c system.c Retarget.c
  group Documentation
    ./: Abstract.txt
