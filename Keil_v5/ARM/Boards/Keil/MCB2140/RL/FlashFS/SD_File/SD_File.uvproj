# Keil uVision project SD_File.uvproj, settings and files
target MCB2140 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: Startup.s File_Config.c SPI_LPC214x.c
  group Com Port
    ./: Serial.c Retarget.c
  group RT Agent
    ./: RTA_Config.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2140 RT_Agent (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: as above
  output: SD_File
  c flags: Optim=4
  c define: RT_AGENT
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
