# Keil uVision project Http_demo.uvproj, settings and files
target MCB2140 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Http_demo
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi system.cgi tcp.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c Serial.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c Startup.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2140 Debug (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
