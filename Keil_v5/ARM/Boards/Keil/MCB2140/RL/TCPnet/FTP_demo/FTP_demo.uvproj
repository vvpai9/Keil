# Keil uVision project FTP_demo.uvproj, settings and files
target MCB2140 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: FTP_demo
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Files
    ./: FTP_demo.c FTP_uif.c SPI_LPC214x.c Serial.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c Startup.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2140 Debug (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: as above
  output: FTP_demo
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
