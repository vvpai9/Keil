# Keil uVision project Memory.uvproj, settings and files
target MCB2140 RTX (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s SWI_Table.s
  group Configuration
    ./: usb_config.c RTX_Conf_LPC21xx.c
  group USB HW Driver
    ./: usbd_LPC214x.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
