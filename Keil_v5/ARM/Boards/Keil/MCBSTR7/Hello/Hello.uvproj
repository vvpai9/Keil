# Keil uVision project Hello.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x30000
  memory RVCT5: ROM 0x40030000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STR71x.s
  group Interrupts
    ./: IRQ.c
  group Retarget
    ./: Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/ST/: STR71x.LIB
  group Source Code
    ./: Hello.c
  group Documentation
    ./: Abstract.txt
target STR7 Eval Board Flash (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x400000
  memory RVCT4: ROM 0x40000000 size 0x30000
  memory RVCT5: ROM 0x40030000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STR7 Eval Board RAM (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
