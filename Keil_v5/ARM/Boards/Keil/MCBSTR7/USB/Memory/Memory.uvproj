# Keil uVision project Memory.uvproj, settings and files
target MCBSTR7 (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STR71x.s
  group Disk Image
    ./: DiskImg.c
  group Source Code
    ./: usbcfg.h usbhw.c usbcore.c usbdesc.c usbuser.c mscuser.c memory.c
  group Library
    C:/Keil/ARM/RV31/LIB/ST/: STR71x.LIB
  group Documentation
    ./: Abstract.txt
