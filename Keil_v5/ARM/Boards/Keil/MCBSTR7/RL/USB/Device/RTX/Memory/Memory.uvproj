# Keil uVision project Memory.uvproj, settings and files
target MCBSTR7 RTX (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IROM2(0x400C0000-0x400C3FFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT5: ROM 0x400c0000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STR71x.s
  group Configuration
    ./: RTX_Conf_STR71x.c usb_config.c
  group USB HW Driver
    ./: usbd_STR71x.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
    C:/Keil/ARM/RV31/LIB/ST/: STR71x.LIB
  group Documentation
    ./: Abstract.txt
