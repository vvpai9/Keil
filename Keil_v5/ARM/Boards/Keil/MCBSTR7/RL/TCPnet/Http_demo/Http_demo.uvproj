# Keil uVision project Http_demo.uvproj, settings and files
target MCBSTR7 (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: Http_demo
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi tcp.cgi system.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c Serial.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c STR71x.s SWI.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    C:/Keil/ARM/RV31/LIB/ST/: STR71x.LIB
  group Documentation
    ./: Abstract.txt
target MCBSTR7 Debug (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
