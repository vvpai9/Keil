# Keil uVision project IAP.uvproj, settings and files
target MCB2100_V162 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: IAP
  c flags: Optim=1
  c define: BYPASS_PLL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Files
    ./: Startup.s IAP.C
  group Documentation
    ./: Abstract.txt
target MCB2100_V163 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: IAP
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
