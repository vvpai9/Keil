# Keil uVision project BlinkyCAN.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: BlinkyCAN
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group System
    ./: Startup.s Retarget.c
  group Source
    ./: mco.c mcohw_LPC2.c user_LPC2.c BlinkyCAN.c
  group Documentation
    ./: Abstract.txt
target MCB2100 Flash (ARM-ADS)
  device: LPC2129 Philips
  cpu: as above
  output: BlinkyCAN
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
target MCB2100 RAM (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: BlinkyCAN
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x3000
  memory RVCT9: RAM 0x40003000 size 0x1000
