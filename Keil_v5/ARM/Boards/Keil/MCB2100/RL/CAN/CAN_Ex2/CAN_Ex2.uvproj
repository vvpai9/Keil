# Keil uVision project CAN_Ex2.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2129 Philips
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: CAN_Ex2
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Configuration
    ./: Startup.s RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_LPC21xx.c
  group Source Files
    ./: CAN_Ex2.c
  group Documentation
    ./: Abstract.txt
target LPC2129 Flash (ARM-ADS)
  device: LPC2129 Philips
  cpu: as above
  output: CAN_Ex2
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
