# Keil uVision project Memory.uvproj, settings and files
target MCBSTR750 (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: STR75x.s
  group Configuration
    ./: usbcfg.h
  group Source Code
    ./: usbcore.c usbdesc.c usbhw.c usbuser.c mscuser.c memory.c DiskImg.c LCD_4bit.c
  group Documentation
    ./: Abstract.txt
