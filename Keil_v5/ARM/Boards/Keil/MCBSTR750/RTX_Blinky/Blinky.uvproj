# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=4
  c define: SIMULATOR
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source
    ./: Blinky.c LCD.c
  group Configuration
    ./: RTX_Config.c STR75x.s
  group Documentation
    ./: Abstract.txt
target MCBSTR750 (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
