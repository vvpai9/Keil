# Keil uVision project Memory.uvproj, settings and files
target MCBSTR750 RTX (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IROM2 (0x200C0000-0x200C3FFF)  IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x4000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: STR75x.s
  group Configuration
    ./: RTX_Conf_STR75x.c usb_config.c
  group USB HW Driver
    ./: usbd_STR75x.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c LCD_4bit.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
