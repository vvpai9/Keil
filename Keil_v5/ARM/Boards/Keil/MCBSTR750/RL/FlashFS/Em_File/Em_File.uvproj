# Keil uVision project Em_File.uvproj, settings and files
target MCBSTR750 (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Em_File
  c flags: Optim=4
  c include: ..\Library;..\Em_File
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Files
    ./: Em_File.c Getline.c Serial.c
  group Configuration Files
    ./: STR75x.s File_Config.c FS_FlashPrg.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
    ../Library/: LCD.c
  group Documentation
    ./: Abstract.txt
