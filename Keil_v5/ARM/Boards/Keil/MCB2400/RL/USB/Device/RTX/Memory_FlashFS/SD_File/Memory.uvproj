# Keil uVision project Memory.uvproj, settings and files
target LPC2468 Flash (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2400.s SWI_Table.s
  group Configuration
    ./: File_Config.c usb_config.c RTX_Conf_LPC24xx.c
  group Drivers
    ./: Serial.c MCI_LPC24xx.c LED.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group USB
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
    ./: usbd_LPC24xx.c usbd_user_msc.c
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
