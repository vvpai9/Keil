# Keil uVision project Memory.uvproj, settings and files
target MCB2400 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Files
    ./: LPC2400.s
  group Configuration
    ./: usb_config.c File_Config.c
  group HW Drivers
    ./: usbd_LPC24xx.c MCI_LPC24xx.c Serial.c
  group File System
    ./: Retarget.c
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group USB
    ./: usbd_user_msc.c
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Main Code
    ./: Getline.c SD_File.c Memory.c
  group Documentation
    ./: Abstract.txt
