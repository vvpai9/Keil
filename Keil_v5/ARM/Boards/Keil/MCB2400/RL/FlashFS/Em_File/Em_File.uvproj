# Keil uVision project Em_File.uvproj, settings and files
target MCB2400 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40017FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Em_File
  c flags: Optim=4
  c include: ..\Em_File
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x18000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Files
    ./: Em_File.c Getline.c
  group Configuration Files
    ./: File_Config.c FS_FlashPrg.c LPC2400.s
  group Com Port
    ./: Serial.c Retarget.c
  group RT Agent
    ./: RTA_Config.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2400 RT_Agent (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: Em_File
  c flags: Optim=4
  c define: RT_AGENT
  c include: ..\Em_File
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x18000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
