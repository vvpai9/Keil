# Keil uVision project NAND_File.uvproj, settings and files
target MCB2400 Flash (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40017FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: NAND_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x18000
  memory RVCT10: RAM 0x7fd00000 size 0x4000
  group Source Files
    ./: Getline.c NAND_File.c
  group Configuration Files
    ./: LPC2400.s File_Config.c NAND_LPC24xx.c
  group Com Port
    ./: Serial.c Retarget.c
  group RT Agent
    ./: RTA_Config.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2400 Flash RT_Agent (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: NAND_File
  c flags: Optim=4
  c define: RT_AGENT
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x18000
  memory RVCT10: RAM 0x7fd00000 size 0x4000
