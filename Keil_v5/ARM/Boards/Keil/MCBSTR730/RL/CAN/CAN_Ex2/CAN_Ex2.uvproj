# Keil uVision project CAN_Ex2.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: CAN_Ex2
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group Configuration
    ./: STR73x.s RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_STR73x.c
  group Source
    ./: CAN_Ex2.c
  group Library
    C:/Keil/ARM/RV31/LIB/ST/: STR73x.LIB
  group Documentation
    ./: Abstract.txt
target STR730 Flash (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: CAN_Ex2
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
