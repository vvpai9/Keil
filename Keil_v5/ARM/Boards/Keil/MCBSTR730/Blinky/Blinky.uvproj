# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group Startup Code
    ./: STR73x.s
  group Interrupts
    ./: IRQ.c
  group System Calls
    ./: Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/ST/: STR73x.LIB
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target STR730 Board - Flash (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x30000
  memory RVCT5: ROM 0x80030000 size 0x10000
  memory RVCT9: RAM 0xa0000000 size 0x4000
