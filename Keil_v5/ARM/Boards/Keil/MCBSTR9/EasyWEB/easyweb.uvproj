# Keil uVision project easyweb.uvproj, settings and files
target MCB-STR9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x87FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: easyweb
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group HTML Source
    ./: webpage.html
  group C Source Files
    ./: easyweb.c tcpip.c ENET.c Retarget.c
  group Configuration Files
    ./: STR91x.s tcpip.h
  group Documentation
    ./: Abstract.txt
