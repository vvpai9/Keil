# Keil uVision project Http_demo.uvproj, settings and files
target MCBSTR9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi lcd.cgi tcp.cgi system.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c STR91x_RTX.s STR91x.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: STR9_ENET.c LCD.c
  group Documentation
    ./: Abstract.txt
target MCBSTR9 Debug (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
target MCBSTR9 RTX (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
