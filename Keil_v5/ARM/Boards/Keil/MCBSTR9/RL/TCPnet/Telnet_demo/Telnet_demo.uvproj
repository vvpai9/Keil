# Keil uVision project Telnet_demo.uvproj, settings and files
target MCBSTR9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c STR91x.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: STR9_ENET.c LCD.c
  group Documentation
    ./: Abstract.txt
target MCBSTR9 Debug (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
