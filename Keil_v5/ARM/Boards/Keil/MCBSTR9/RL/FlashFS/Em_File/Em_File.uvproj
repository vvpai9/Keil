# Keil uVision project Em_File.uvproj, settings and files
target MCBSTR9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Em_File
  c flags: Optim=1
  c include: ..\Library;..\Em_File
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Source Files
    ./: Em_File.c Getline.c
  group Configuration Files
    ./: File_Config.c FS_FlashPrg.c STR91x.s
  group Com Port
    ./: Serial.c Retarget.c
  group RT Agent
    ./: RTA_Config.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
    ../Library/: LCD.c
  group Documentation
    ./: Abstract.txt
target MCBSTR9 RT_Agent (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Em_File
  c flags: Optim=1
  c define: RT_AGENT
  c include: ..\Library;..\Em_File
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
