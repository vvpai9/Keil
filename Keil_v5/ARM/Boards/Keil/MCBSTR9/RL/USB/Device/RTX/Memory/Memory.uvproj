# Keil uVision project Memory.uvproj, settings and files
target MCBSTR9 RTX (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Memory
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Startup Code
    ./: STR91x.s
  group Configuration
    ./: RTX_Conf_STR91x.c usb_config.c
  group USB HW Driver
    ./: usbd_STR91x.c
  group Source
    ./: USBD_Demo.c DiskImg.c usbd_user_msc.c LCD_8bit.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
