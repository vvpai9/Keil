# Keil uVision project CAN_Ex1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x87FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Configuration
    ./: STR91x.s RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_STR91x.c
  group Source
    ./: CAN_Ex1.c LCD.c UserFont.c
  group Library
    C:/Keil/ARM/RV31/LIB/ST/: STR91xR.LIB
  group Documentation
    ./: Abstract.txt
target STR910 Flash (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
