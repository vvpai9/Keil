# Keil uVision project Measure.uvproj, settings and files
target MCBSTR9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x87FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Measure
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Startup Code
    ./: STR91x.s
  group System Calls
    ./: Retarget.c Serial.c LCD.c UserFont.c
  group Source Code
    ./: Measure.c Mcommand.c Getline.c
  group Documentation
    ./: Abstract.txt
target Simulator (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Measure
  c flags: Optim=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
