# Keil uVision project TRAFFIC.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: TRAFFIC
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Source Files
    ./: Traffic.c Serial.c Getline.c LCD.c
  group Configuration
    ./: RTX_Config.c STR91x.s
  group Documentation
    ./: Abstract.txt
target MCBSTR9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: TRAFFIC
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
