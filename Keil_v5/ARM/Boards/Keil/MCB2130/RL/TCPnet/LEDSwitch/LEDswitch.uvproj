# Keil uVision project LEDswitch.uvproj, settings and files
target MCB2130 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LEDswitch
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Files
    ./: LEDSwitch.c Serial.c
  group Configuration Files
    ./: Startup.s Net_Config.c Net_Debug.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2130 Debug (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: as above
  output: LEDswitch
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
