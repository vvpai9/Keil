# Keil uVision project Voice.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Voice
  AfterMake: .\AudioData\convert.bat
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: T0Int.c Main.c
  group Documentation
    ./: Abstract.txt
target MCB2130 Flash (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: as above
  output: Voice
  AfterMake: .\AudioData\convert.bat
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
