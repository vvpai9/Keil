# Keil uVision project TRAFFIC.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: TRAFFIC
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Files
    ./: Traffic.c Serial.c Getline.c LCD.c
  group Configuration
    ./: RTX_Config.c LPC2300.s
  group Documentation
    ./: Abstract.txt
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: TRAFFIC
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
