# Keil uVision project CAN.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: CanDemo
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2300.s
  group Source
    ./: CAN.c CanDemo.c ADC.c LED.c
  group Driver
    ./: LCD_4bit.c
  group RT Agent
    ./: RTA_Config.c RTA_LPC2300.s
  group Documentation
    ./: Abstract.txt
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
target MCB2300 RTA (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: RT_AGENT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
