# Keil uVision project MSD_File.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2388 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MSD_File
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fd00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c Serial.c fs_usbh_msc.c usbh_ohci_lpc23xx.c LCD.c
  group RT Agent
    ./: RTA_Config.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2300 RT_Agent (ARM-ADS)
  device: LPC2388 NXP (founded by Philips)
  cpu: as above
  output: MSD_File
  c flags: Optim=4
  c define: RT_AGENT
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fd00000 size 0x4000
