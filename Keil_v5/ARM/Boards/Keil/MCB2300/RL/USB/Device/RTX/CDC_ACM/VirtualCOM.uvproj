# Keil uVision project VirtualCOM.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: VirtualCOM
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2300.s SWI_Table.s
  group Configuration
    ./: RTX_Conf_LPC23xx.c usb_config.c
  group USB HW Driver
    ./: usbd_LPC23xx.c
  group Source
    ./: USBD_Demo.c LCD_4bit.c UART_LPC23xx.c usbd_user_cdc_acm.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
