# Keil uVision project Http_demo.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000E7FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi lcd.cgi leds.cgi system.cgi tcp.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c LPC2300.s LPC2300_RTX.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: LPC23_EMAC.c LCD.c
  group Documentation
    ./: Abstract.txt
target MCB2300 Debug (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
target MCB2300 RTX (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
