# Keil uVision project BSD_client.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000E7FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: BSD_client
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Files
    ./: BSD_client.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c LPC2300.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: LPC23_EMAC.c LCD.c
  group Documentation
    ./: Abstract.txt
target MCB2300 Debug (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: BSD_client
  c flags: Optim=4 OneElfS=1
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
