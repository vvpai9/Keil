# Keil uVision project easyweb.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: easyweb
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group HTML Source
    ./: webpage.html
  group C Source Files
    ./: easyweb.c tcpip.c EMAC.c Retarget.c
  group Configuration Files
    ./: LPC2300.s tcpip.h
  group Documentation
    ./: Abstract.txt
