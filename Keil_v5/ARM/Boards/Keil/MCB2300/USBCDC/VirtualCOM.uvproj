# Keil uVision project VirtualCOM.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: VirtualCOM
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group Startup Code
    ./: LPC2300.s
  group Source Code
    ./: LCD_4bit.c serial.c SWI.s usbcfg.h usbhw.c usbcore.c usbdesc.c usbuser.c cdcuser.c vcomdemo.c
  group Documentation
    ./: Abstract.txt
