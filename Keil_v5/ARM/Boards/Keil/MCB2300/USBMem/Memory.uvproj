# Keil uVision project Memory.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group Startup Files
    ./: LPC2300.s
  group Source Files
    ./: usbcfg.h usbcore.c usbdesc.c usbhw.c usbuser.c mscuser.c memory.c DiskImg.c LCD_4bit.c
  group Documentation
    ./: Abstract.txt
