# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2919 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000BFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xc000
  group Source
    ./: Blinky.c LCD_4bit.c
  group Configuration
    ./: RTX_Config.c LPC29xx.s
  group Documentation
    ./: Abstract.txt
target MCB2900 (ARM-ADS)
  device: LPC2919 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xc000
