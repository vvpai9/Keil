# Keil uVision project CAN_Ex2.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2919 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000BFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: CAN_Ex2
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xc000
  group Configuration
    ./: LPC29xx.s RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_LPC29xx.c
  group Source
    ./: CAN_Ex2.c LCD_4bit.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LPC2919 Flash (ARM-ADS)
  device: LPC2919 NXP (founded by Philips)
  cpu: as above
  output: CAN_Ex2
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xc000
