# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2919 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x8000BFFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xc000
  group Startup Code
    ./: LPC29xx.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Blinky.c LCD_4bit.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LPC2919 Flash (ARM-ADS)
  device: LPC2919 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0xc000
