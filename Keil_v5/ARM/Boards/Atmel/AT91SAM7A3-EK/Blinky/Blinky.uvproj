# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x13FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
  group Startup Code
    ./: SAM7.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM7A3 Flash - ULINK (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
target SAM7A3 RAM - ULINK (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x204000 size 0x4000
target SAM7A3 Flash - SAMICE (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
