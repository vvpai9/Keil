# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x13FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c SAM7.s
  group Documentation
    ./: Abstract.txt
target AT91SAM7A3 (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
