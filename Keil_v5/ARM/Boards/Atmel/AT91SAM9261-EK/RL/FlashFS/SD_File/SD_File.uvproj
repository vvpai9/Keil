# Keil uVision project SD_File.uvproj, settings and files
target AT91SAM9261 (ARM-ADS)
  device: AT91SAM9261 Atmel
  cpu: IRAM(0x300000-0x327FFF) IROM(0x400000-0x407FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: SD_File
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x28000
  group Source Files
    ./: Getline.c SD_File.c
  group Configuration Files
    ./: SAM9261.s File_Config.c MCI_SAM9261.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
