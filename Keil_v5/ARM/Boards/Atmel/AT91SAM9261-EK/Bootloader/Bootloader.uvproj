# Keil uVision project Bootloader.uvproj, settings and files
target SAM9261_DF_P1056_CS0_BL (ARM-ADS)
  device: AT91SAM9261 Atmel
  cpu: IRAM(0x300000-0x327FFF) IROM(0x400000-0x407FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: SAM9261_DF_P1056_CS0_BL
  c flags: Optim=1
  c define: P1056_CS0
  c misc: --diag_suppress 61
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
  group Bootloader Code
    ./: SAM9261.s Bootloader.c DFlashHW.c
  group Documentation
    ./: Abstract.txt
target SAM9261_DF_P1056_CS0 - SAMICE (ARM-ADS)
  device: AT91SAM9261 Atmel
  cpu: as above
  output: SAM9261_DF_P1056_CS0_BL
  c flags: Optim=1
  c define: P1056_CS0
  c misc: --diag_suppress 61
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
