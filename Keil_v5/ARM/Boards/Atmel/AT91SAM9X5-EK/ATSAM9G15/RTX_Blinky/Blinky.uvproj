# Keil uVision project Blinky.uvproj, settings and files
target SAM9G15 (ARM-ADS)
  device: SAM9G15 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x100000-0x10FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  c include: ..\
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x400000
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT6: RAM 0x22000000 size 0x400000
  memory RVCT9: RAM 0x300000 size 0x8000
  group Source
    ./: Blinky.c SAM9G15.s
  group Configuration
    ./: RTX_Conf_SAM9G15.c
  group Documentation
    ./: Abstract.txt
