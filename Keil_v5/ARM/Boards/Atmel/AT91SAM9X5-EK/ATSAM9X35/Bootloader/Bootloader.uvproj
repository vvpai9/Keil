# Keil uVision project Bootloader.uvproj, settings and files
target AT25DF321_CS0 (ARM-ADS)
  device: SAM9X35 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x100000-0x10FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Bootloader
  c flags: Optim=1
  c define: P528_CS0
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT9: RAM 0x300e00 size 0x1200
  group Bootloader Code
    ./: Bootloader.c DFlashHW.c SAM9X35.s
  group Documentation
    ./: Abstract.txt
