# Keil uVision project Blinky.uvproj, settings and files
target SAM9263 Int RAM (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: IRAM(0x300000-0x313FFF) IROM(0x400000-0x41FFFF) CLOCK(16367660) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  c include: ..\..\AT91SAM9263-EK
  asm define: SIZE_INT_INFO NO_SDRAM_INIT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x310000 size 0x4000
  group Source Code
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c SAM9263.s
  group Documentation
    ./: Abstract.txt
target SAM9263 Ext SDRAM (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: ..\..\AT91SAM9263-EK
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x14000
