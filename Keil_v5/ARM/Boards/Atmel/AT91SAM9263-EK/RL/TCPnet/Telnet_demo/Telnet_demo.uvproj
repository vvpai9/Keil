# Keil uVision project Telnet_demo.uvproj, settings and files
target AT91SAM9263 (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: IRAM(0x300000-0x313FFF) IROM(0x400000-0x41FFFF) CLOCK(16367660) CPUTYPE(ARM926EJ-S)
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9263-EK
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x14000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c SAM9263.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: EMAC_SAM9263.c
  group Documentation
    ./: Abstract.txt
target AT91SAM9263 Debug (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9263-EK
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x14000
