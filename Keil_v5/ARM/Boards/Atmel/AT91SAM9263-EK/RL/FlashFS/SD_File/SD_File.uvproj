# Keil uVision project SD_File.uvproj, settings and files
target AT91SAM9263 (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: IRAM(0x300000-0x313FFF) IROM(0x400000-0x41FFFF) CLOCK(16367660) CPUTYPE(ARM926EJ-S)
  output: SD_File
  c flags: Optim=1
  c misc: --diag_suppress 61
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x14000
  group Source Files
    ./: Getline.c SD_File.c
  group Configuration Files
    ./: SAM9263.s File_Config.c MCI_SAM9263.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
