# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: IRAM(0x00200000-0x00203FFF) IROM(0x00100000-0x0011FFFF) CLOCK(18430000) CPUTYPE(ARM920T)
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c RM9200.s
  group Documentation
    ./: Abstract.txt
target AT91RM9200 (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
