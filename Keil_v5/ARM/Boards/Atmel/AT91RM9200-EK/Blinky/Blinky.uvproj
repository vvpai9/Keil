# Keil uVision project Blinky.uvproj, settings and files
target RM9200 Ext Flash (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: IRAM(0x00200000-0x00203FFF) IROM(0x00100000-0x0011FFFF) CLOCK(18430000) CPUTYPE(ARM920T)
  output: Blinky
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  group Startup Code
    ./: RM9200.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target RM9200 Int RAM (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: as above
  output: Blinky
  asm define: REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT4: ROM 0x200000 size 0x2000
  memory RVCT6: RAM 0x20000000 size 0x2000000
  memory RVCT9: RAM 0x202000 size 0x2000
target RM9200 Ext SDRAM Debug (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: as above
  output: Blinky
  asm define: REMAP RAM_INTVEC NO_SDRAM_INIT
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x1000000
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT6: RAM 0x21000000 size 0x1000000
  memory RVCT9: RAM 0x200040 size 0x4000
target RM9200 Ext SDRAM (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: as above
  output: Blinky
  asm define: RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x1000000
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT6: RAM 0x21000000 size 0x1000000
  memory RVCT9: RAM 0x200000 size 0x4000
  scatter file: .\ROM_to_RAM.sct
