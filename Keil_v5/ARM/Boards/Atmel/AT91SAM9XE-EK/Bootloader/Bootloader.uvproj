# Keil uVision project Bootloader.uvproj, settings and files
target SAM9XE_DF_P1056_CS1_BL (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x200000-0x27FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: SAM9XE_DF_P1056_CS1_BL
  c flags: Optim=1
  c define: P1056_CS1
  c misc: --diag_suppress 61
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x200000 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x200
  group Bootloader Code
    ./: SAM9XE.s Bootloader.c DFlashHW.c
  group Documentation
    ./: Abstract.txt
target SAM9XE_DF_P1056_CS1 - SAMICE (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: SAM9XE_DF_P1056_CS1_BL
  c flags: Optim=1
  c define: P1056_CS1
  c misc: --diag_suppress 61
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x200000 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x200
