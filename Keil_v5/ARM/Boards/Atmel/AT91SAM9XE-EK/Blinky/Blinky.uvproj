# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x200000-0x27FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x8000
  group Startup Code
    ./: SAM9XE.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM9XE Int RAM (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x2000
  memory RVCT9: RAM 0x302000 size 0x2000
target SAM9XE Int Flash (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x8000
target SAM9XE Ext SDRAM (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x8000
target SAM9XE Ext SDRAM - SAMICE (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x8000
