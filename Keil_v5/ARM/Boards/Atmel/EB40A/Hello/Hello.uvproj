# Keil uVision project Hello.uvproj, settings and files
target Sim AT91R40008 (ARM-ADS)
  device: AT91R40008 Atmel
  cpu: IRAM(0-0x3FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20 size 0x3ffe0
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Hello.c
  group Documentation
    ./: Abstract.txt
target RAM AT91R40008 (ARM-ADS)
  device: AT91R40008 Atmel
  cpu: IRAM(0-0x3FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x10000 size 0x20000
  memory RVCT9: RAM 0x30000 size 0x10000
target Flash AT91R40008 (ARM-ADS)
  device: AT91R40008 Atmel
  cpu: IRAM(0-0x3FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20 size 0x3ffe0
target ERAM AT91R40008 (ARM-ADS)
  device: AT91R40008 Atmel
  cpu: IRAM(0-0x3FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  memory RVCT1: ROM 0x1000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x30000 size 0x10000
  scatter file: .\ERAM.sct
