# Keil uVision project Bootloader.uvproj, settings and files
target SAM9G20_DF_P1056_CS1_BL (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: IRAM(0x200000-0x203FFF) IRAM2(0x300000-0x303FFF) IROM(0x100000-0x10FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: SAM9G20_DF_P1056_CS1_BL
  c flags: Optim=1
  c define: P1056_CS1
  c misc: --diag_suppress 61,68
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
  group Bootloader Code
    ./: SAM9G20.s Bootloader.c DFlashHW.c
  group Documentation
    ./: Abstract.txt
target SAM9G20_DF_P1056_CS1 - SAMICE (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: as above
  output: SAM9G20_DF_P1056_CS1_BL
  c flags: Optim=1
  c define: P1056_CS1
  c misc: --diag_suppress 61,68
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
