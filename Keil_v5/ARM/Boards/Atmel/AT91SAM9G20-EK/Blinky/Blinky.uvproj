# Keil uVision project Blinky.uvproj, settings and files
target SAM9G20 Int RAM (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: IRAM(0x200000-0x203FFF) IRAM2(0x300000-0x303FFF) IROM(0x100000-0x10FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_INT_INFO NO_SDRAM_INIT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x300000 size 0x4000
  group Startup Code
    ./: SAM9G20.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM9G20 Ext SDRAM (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  memory RVCT10: RAM 0x300000 size 0x4000
target SAM9G20 Ext SDRAM - SAMICE (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  memory RVCT10: RAM 0x300000 size 0x4000
