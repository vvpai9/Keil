# Keil uVision project MSD_File.uvproj, settings and files
target SAM9G20 (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: IRAM(0x200000-0x203FFF) IRAM2(0x300000-0x303FFF) IROM(0x100000-0x10FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: MSD_File
  c flags: Optim=4
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  memory RVCT10: RAM 0x300000 size 0x4000
  group Startup
    ./: SAM9G20.s
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c Serial.c fs_usbh_msc.c usbh_ohci_SAM9G20.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
