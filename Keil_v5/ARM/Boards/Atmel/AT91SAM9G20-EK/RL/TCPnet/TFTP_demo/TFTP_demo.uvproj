# Keil uVision project TFTP_demo.uvproj, settings and files
target SAM9G20 (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: IRAM(0x200000-0x203FFF) IRAM2(0x300000-0x303FFF) IROM(0x100000-0x10FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: TFTP_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9G20-EK
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  memory RVCT1: ROM 0x20000000 size 0x1000000
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT6: RAM 0x21000000 size 0x1000000
  memory RVCT7: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  memory RVCT10: RAM 0x300000 size 0x4000
  group Source Files
    ./: TFTP_demo.c TFTP_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c File_Config.c Retarget.c SAM9G20.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib FS_ARM_L.lib
    ../Library/: EMAC_SAM9G20.c
  group Documentation
    ./: Abstract.txt
target SAM9G20 Debug (ARM-ADS)
  device: SAM9G20 Atmel
  cpu: as above
  output: TFTP_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9G20-EK
  asm define: as above
  memory RVCT1: ROM 0x20000000 size 0x1000000
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT6: RAM 0x21000000 size 0x1000000
  memory RVCT7: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x4000
  memory RVCT10: RAM 0x300000 size 0x4000
