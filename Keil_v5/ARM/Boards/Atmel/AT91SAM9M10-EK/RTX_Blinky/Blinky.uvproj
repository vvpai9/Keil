# Keil uVision project Blinky.uvproj, settings and files
target SAM9M10 (ARM-ADS)
  device: AT91SAM9M10 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  c include: ../
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x70000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT6: RAM 0x72000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x10000
  group Source
    ./: Blinky.c SAM9M10.s
  group Configuration
    ./: RTX_Conf_SAM9M10.c
  group Documentation
    ./: Abstract.txt
