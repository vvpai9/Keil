# Keil uVision project Http_demo.uvproj, settings and files
target AT91SAM9260 (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9260-EK
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi tcp.cgi system.cgi language.cgi buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c SAM9260.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: EMAC_SAM9260.c
  group Documentation
    ./: Abstract.txt
target AT91SAM9260 Debug (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9260-EK
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
target AT91SAM9260 RTX (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library;..\..\..\..\AT91SAM9260-EK
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
