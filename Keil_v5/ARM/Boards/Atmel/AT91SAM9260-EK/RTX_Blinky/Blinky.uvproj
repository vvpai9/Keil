# Keil uVision project Blinky.uvproj, settings and files
target AT91SAM9260 (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=4
  c include: ..\..\AT91SAM9260-EK
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c SAM9260.s
  group Documentation
    ./: Abstract.txt
