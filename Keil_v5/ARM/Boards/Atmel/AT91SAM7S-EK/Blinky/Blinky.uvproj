# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Startup Code
    ./: SAM7.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM7S Flash - ULINK (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: as above
  output: Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
target SAM7S RAM - ULINK (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: as above
  output: Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
target SAM7S Flash - SAMICE (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: as above
  output: Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
