# Keil uVision project Hello.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Startup Code
    ./: SAM7.s
  group System Calls
    ./: Retarget.c Serial.c Time.c
  group Source Code
    ./: IRQ0.s ExtInt.c Hello.c
  group Documentation
    ./: Abstract.txt
target AT91SAM7S Flash (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
target AT91SAM7S FRIRQ (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: .\FRIRQ.sct
target AT91SAM7S RAM (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x2000
  memory RVCT9: RAM 0x202000 size 0x2000
