# Keil uVision project MSD_File.uvproj, settings and files
target SAM9G45 (ARM-ADS)
  device: SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: MSD_File
  c flags: Optim=4
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  memory RVCT1: ROM 0x70000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT6: RAM 0x74000000 size 0x4000000
  memory RVCT9: RAM 0x300000 size 0x10000
  group Startup
    ./: SAM9G45.s
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c Serial.c fs_usbh_msc.c usbh_ohci_SAM9G45.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
