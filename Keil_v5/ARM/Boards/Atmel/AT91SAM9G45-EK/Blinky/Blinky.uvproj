# Keil uVision project Blinky.uvproj, settings and files
target SAM9G45 Int RAM (ARM-ADS)
  device: SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_INT_INFO NO_SDRAM_INIT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x308000 size 0x8000
  group Startup Code
    ./: SAM9G45.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM9G45 Ext SDRAM (ARM-ADS)
  device: SAM9G45 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x70000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT6: RAM 0x72000000 size 0x2000000
  memory RVCT9: RAM 0x308000 size 0x8000
target SAM9G45 Ext SDRAM - SAMICE (ARM-ADS)
  device: SAM9G45 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x70000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT6: RAM 0x72000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x10000
