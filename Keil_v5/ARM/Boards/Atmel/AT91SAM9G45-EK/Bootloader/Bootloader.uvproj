# Keil uVision project Bootloader.uvproj, settings and files
target SAM9G45_DF_P528_CS0_BL (ARM-ADS)
  device: SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Bootloader
  c flags: Optim=1
  c define: P528_CS0
  c misc: --diag_suppress 61,68
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x70000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x72000000 size 0x7000000
  memory RVCT9: RAM 0x300e00 size 0x200
  group Bootloader Code
    ./: SAM9G45.s Bootloader.c DFlashHW.c
  group Documentation
    ./: Abstract.txt
target SAM9G45_DF_P528_CS0 - SAMICE (ARM-ADS)
  device: SAM9G45 Atmel
  cpu: as above
  output: SAM9G45_DF_P528_CS0_BL
  c flags: Optim=1
  c define: P528_CS0
  c misc: --diag_suppress 61,68
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x70000000 size 0x2000000
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT6: RAM 0x72000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x10000
