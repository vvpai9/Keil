# Keil uVision project Bootloader.uvproj, settings and files
target SAM9RL_DF_P1056_BL (ARM-ADS)
  device: AT91SAM9RL64 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x407FFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: SAM9RL_DF_P1056_BL
  c flags: Optim=1
  c misc: --diag_suppress 61
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
  group Bootloader Code
    ./: SAM9RL.s Bootloader.c DFlashHW.c
  group Documentation
    ./: Abstract.txt
target SAM9RL_DF_P1056_BL - SAMICE (ARM-ADS)
  device: AT91SAM9RL64 Atmel
  cpu: as above
  output: SAM9RL_DF_P1056_BL
  c flags: Optim=1
  c misc: --diag_suppress 61
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
