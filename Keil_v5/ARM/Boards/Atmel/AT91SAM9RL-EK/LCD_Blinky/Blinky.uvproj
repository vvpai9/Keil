# Keil uVision project Blinky.uvproj, settings and files
target SAM9RL Ext SDRAM (ARM-ADS)
  device: AT91SAM9RL64 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x407FFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x400000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x10000
  group Startup Code
    ./: SAM9RL.s
  group Source Code
    ./: Blinky.c GLCD.c
  group Pictures
    ./: Background_24bpp_rl_fv.c ARM_Ani_24bpp_rl_fv.c
  group Documentation
    ./: Abstract.txt
