# Keil uVision project Blinky.uvproj, settings and files
target AT91SAM9RL (ARM-ADS)
  device: AT91SAM9RL64 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x407FFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x400000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300000 size 0x10000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c SAM9RL.s
  group Documentation
    ./: Abstract.txt
