# Keil uVision project Memory.uvproj, settings and files
target AT91SAM7X-EK (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Startup Code
    ./: SAM7.s
  group Disk Image
    ./: DiskImg.c
  group Source Code
    ./: usbcfg.h usbcore.c usbdesc.c usbuser.c mscuser.c memory.c usbhw_SAM7X.c
  group Documentation
    ./: Abstract.txt
