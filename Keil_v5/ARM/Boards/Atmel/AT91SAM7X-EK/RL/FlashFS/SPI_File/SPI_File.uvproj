# Keil uVision project SPI_File.uvproj, settings and files
target AT91SAM7X-321 (ARM-ADS)
  device: AT91SAM7XC256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: SPI_File
  c flags: Optim=4
  c include: ..\Library;..\SPI_File
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Source Files
    ./: SPI_File.c Getline.c
  group Configuration Files
    ./: SAM7.s File_Config.c File_Conf_642.c FS_SPI_FlashPrg.c FS_SPI_FlPrg_642.c SPI_SAM7X.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target AT91SAM7X-642 (ARM-ADS)
  device: AT91SAM7XC256 Atmel
  cpu: as above
  output: SD_File
  c flags: Optim=4
  c include: ..\Library;..\SPI_File
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
