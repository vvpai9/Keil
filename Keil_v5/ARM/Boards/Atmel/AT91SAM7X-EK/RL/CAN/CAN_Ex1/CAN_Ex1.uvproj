# Keil uVision project CAN_Ex1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: CAN_Ex1
  c flags: Optim=4
  c include: ..\..\..\..\AT91SAM7X-EK; .\
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Configuration
    ./: SAM7.s RTX_Config.c
  group CAN Core
    ./: CAN_Cfg.h
    C:/Keil/ARM/RL/CAN/SRC/: RTX_CAN.c
  group CAN Driver
    ./: CAN_SAM7X.c
  group Source
    ./: CAN_Ex1.c
  group Documentation
    ./: Abstract.txt
target SAM7X Flash (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: as above
  output: CAN_Ex1
  c flags: Optim=4
  c include: ..\..\..\..\AT91SAM7X-EK; .\
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
