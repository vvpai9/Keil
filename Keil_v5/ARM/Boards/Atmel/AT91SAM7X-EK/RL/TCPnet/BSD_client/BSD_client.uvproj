# Keil uVision project BSD_client.uvproj, settings and files
target AT91SAM7X (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: BSD_client
  c flags: Optim=4
  c misc: --diag_suppress 61
  c include: ..\Library;..\..\..\..\AT91SAM7X-EK
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Source Files
    ./: BSD_client.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c SAM7.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: EMAC_SAM7X.c
  group Documentation
    ./: Abstract.txt
target AT91SAM7X Debug (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: as above
  output: BSD_client
  c flags: Optim=4
  c misc: --diag_suppress 61
  c include: ..\Library;..\..\..\..\AT91SAM7X-EK
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
