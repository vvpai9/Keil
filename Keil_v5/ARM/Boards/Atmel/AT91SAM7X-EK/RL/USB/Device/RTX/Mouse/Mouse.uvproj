# Keil uVision project Mouse.uvproj, settings and files
target SAM7X-EK RTX (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: Mouse
  c flags: Optim=4
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Startup Code
    ./: SAM7.s
  group Configuration
    ./: usb_config.c RTX_Config.c
  group USB HW Driver
    ./: usbd_SAM7X.c
  group Source
    ./: USBD_Demo.c usbd_user_hid.c usbd_user_desc.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
