# Keil uVision project easyweb.uvproj, settings and files
target AT91SAM7X (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: easyweb
  c flags: Optim=1
  c misc: --diag_suppress 61
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group HTML Source
    ./: webpage.html
  group C Source Files
    ./: easyweb.c tcpip.c EMAC.c Retarget.c
  group Configuration Files
    ./: SAM7.s tcpip.h
  group Documentation
    ./: Abstract.txt
