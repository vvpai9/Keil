# Keil uVision project Blinky.uvproj, settings and files
target AS3525 Int RAM (ARM-ADS)
  device: AS3525 AustriaMicroSystems
  cpu: IRAM(0x81000000-0x8104FFFF) IROM(0x80000000-0x8001FFFF) CLOCK(24000000) CPUTYPE(ARM922T)
  output: Blinky
  c flags: Optim=1
  c define: CLOCK_INIT SDRAM_INIT
  c include: C:\Keil\ARM\INC\AMS\AS352x\include
  library: MicroLIB
  memory RVCT4: ROM 0x81000000 size 0x40000
  memory RVCT9: RAM 0x81040000 size 0x10000
  group Startup Code
    ./: AS352x.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target AS3525 Ext M25P40 Flash (ARM-ADS)
  device: AS3525 AustriaMicroSystems
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: CLOCK_INIT SDRAM_INIT
  c include: C:\Keil\ARM\INC\AMS\AS352x\include
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x800000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x30800000 size 0x800000
  memory RVCT9: RAM 0x81040000 size 0x10000
target AS3525 Ext SDRAM (ARM-ADS)
  device: AS3525 AustriaMicroSystems
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: C:\Keil\ARM\INC\AMS\AS352x\include
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x800000
  memory RVCT4: ROM 0x80000000 size 0x20000
  memory RVCT6: RAM 0x30800000 size 0x800000
  memory RVCT9: RAM 0x81000040 size 0x50000
