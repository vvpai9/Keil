# Keil uVision project Blinky.uvproj, settings and files
target ML674000 (ARM-ADS)
  device: ML674000 OKI
  cpu: IRAM(0x10000000-0x10001FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x200000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT7: RAM 0xd0000000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c ML674K.s
  group Documentation
    ./: Abstract.txt
