# Keil uVision project Blinky.uvproj, settings and files
target ML674000 Flash (ARM-ADS)
  device: ML674000 OKI
  cpu: IRAM(0x10000000-0x10001FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT7: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup Code
    ./: ML674K.s
  group System Calls
    ./: IRQSYS.s IRQ.c Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ML674000 SRAM (ARM-ADS)
  device: ML674000 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x80000
  memory RVCT2: ROM 0xd0000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT9: RAM 0x10000000 size 0x2000
target ML674000 DRAM (ARM-ADS)
  device: ML674000 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x80000
  memory RVCT2: ROM 0xc0000000 size 0x800000
  memory RVCT6: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x2000
