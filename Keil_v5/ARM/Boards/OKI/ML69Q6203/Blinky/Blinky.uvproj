# Keil uVision project Blinky.uvproj, settings and files
target ML69Q6203 Flash (ARM-ADS)
  device: ML69Q6203 OKI
  cpu: IRAM(0x50000000-0x5001FFFF) IROM(0xC8000000-0xC807FFFF) CLOCK(60000000) CPUTYPE(ARM946E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x4000000
  memory RVCT7: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x50000000 size 0x20000
  group Startup Code
    ./: ML696200.s
  group System Calls
    ./: IRQSYS.s IRQ.c Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ML69Q6203 IRAM (ARM-ADS)
  device: ML69Q6203 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x50000000 size 0x10000
  memory RVCT6: RAM 0xc0000000 size 0x4000000
  memory RVCT7: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x50010000 size 0x10000
target ML69Q6203 SRAM (ARM-ADS)
  device: ML69Q6203 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xd0000000 size 0x80000
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x4000000
  memory RVCT9: RAM 0x50000000 size 0x20000
target ML69Q6203 DRAM (ARM-ADS)
  device: ML69Q6203 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x4000000
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x50000000 size 0x20000
