# Keil uVision project Blinky.uvproj, settings and files
target ML67Q4051 Int. Flash (ARM-ADS)
  device: ML67Q4051 OKI
  cpu: IRAM(0x10000000-0x10007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x400000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0xd0000000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Startup Code
    ./: ML674050.s
  group System Calls
    ./: IRQSYS.s IRQ.c Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ML67Q4051 Ext. Flash (ARM-ADS)
  device: ML67Q4051 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x400000
  memory RVCT4: ROM 0x8000000 size 0x4e20
  memory RVCT6: RAM 0xd0000000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x8000
target ML67Q4051 Ext. SRAM (ARM-ADS)
  device: ML67Q4051 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x80000
  memory RVCT2: ROM 0xc8100000 size 0x400000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
