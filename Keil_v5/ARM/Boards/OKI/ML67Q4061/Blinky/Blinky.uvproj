# Keil uVision project Blinky.uvproj, settings and files
target ML67Q4061 Int. Flash (ARM-ADS)
  device: ML67Q4061 OKI
  cpu: IRAM(0x10000000-0x10007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Startup Code
    ./: ML674050.s
  group System Calls
    ./: IRQSYS.s IRQ.c Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ML67Q4061 Int. RAM (ARM-ADS)
  device: ML67Q4061 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x10002000 size 0x2000
