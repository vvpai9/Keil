# Keil uVision project Blinky.uvproj, settings and files
target ML67Q5003 Flash (ARM-ADS)
  device: ML675003 OKI
  cpu: IRAM(0x50000000-0x50007FFF) IROM(0xC8000000-0xC807FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT7: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x50000000 size 0x8000
  group Startup Code
    ./: ML675K.s
  group System Calls
    ./: IRQSYS.s IRQ.c Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ML67Q5003 IRAM (ARM-ADS)
  device: ML675003 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x50000000 size 0x4000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT7: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x50004000 size 0x4000
target ML67Q5003 SRAM (ARM-ADS)
  device: ML675003 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xd0000000 size 0x80000
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT9: RAM 0x50000000 size 0x8000
target ML67Q5003 DRAM (ARM-ADS)
  device: ML675003 OKI
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x800000
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xd0000000 size 0x80000
  memory RVCT9: RAM 0x50000000 size 0x8000
