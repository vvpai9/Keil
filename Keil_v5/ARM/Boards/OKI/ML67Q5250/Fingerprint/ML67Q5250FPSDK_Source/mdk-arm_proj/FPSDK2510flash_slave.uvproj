# Keil uVision project FPSDK2510flash_slave.uvproj, settings and files
target FPSDK2510flash_slave (ARM-ADS)
  device: ML67Q5250 OKI
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: FPSDK2510flash_slave +hex
  AfterMake: cmd /C "move @L_Data\@H.hex @L_Data\flash_data.hex"
  c flags: Optim=4
  c define: AE_SUPPORT_AES2510 USE_STDOUT_USB
  c misc: --dwarf2
  c include: ..\source\APP\inc;..\source\DigitalIndicator;..\source\DMAC;..\source\FLASH;..\source\FPAE;..\source\FPSP;..\source\HAL\hal_wrap;..\source\HAL\ML675250\INC;..\source\KEY\inc;..\source\LED\inc;..\source\Sensor;..\source\Sensor\SlideSensor;..\source\SIO\inc;..\source\SPI;..\source\SSIO;..\source\Timer\inc;..\source\UsbPeri\Drv\inc;..\source\UsbPeri\USBFp
  asm define: top_of_memory=0x10004000
  asm misc: --dwarf2
  asm include: ..\source\HAL\ML675250\INC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  link misc: --first=init.o(Vector)
  group FPSDK
    ../source/APP/: main.c
  group APP
    ../source/APP/src/: unused_port.c Assert.c console_out.c Indicator.c IndicatorDevKit.c main_spectral_demo.c
  group DMAC
    ../source/DMAC/: dmac.c
  group FLASH
    ../source/FLASH/: flash_sdp.c flash_memory.c
  group FPAE
    ../source/FPAE/: tsmwrp.c fpaehal.c
  group FPSP
    ../source/FPSP/: fpsp_wrp_rel.c fpsp_heap.c
  group KEY
    ../source/KEY/src/: key.c
  group ml675250
    ../source/HAL/ML675250/SRC/: retarget.c irq.c irq_api.c swi_handler.s init.s irq_handler.s stack.s
  group SPI
    ../source/SPI/: spi.c
  group Sensor
    ../source/Sensor/SlideSensor/: sensor_port.c sensor_heap.c
  group Timer
    ../source/Timer/src/: timera.c
  group DigitalIndicator
    ../source/DigitalIndicator/: digital_indicator.c
  group SIO
    ../source/SIO/src/: sio.c
  group SSIO
    ../source/SSIO/: ssio.c
  group LED
    ../source/LED/src/: led.c
  group Lib
    ../mdk-arm_lib/: mFPAE.lib mFPSP.lib mSensor2510slave.lib
  group UsbPeri_Drv
    ../source/UsbPeri/Drv/src/: descript.c intr.c req_clss.c request.c trans.c usb_api.c usb_init.c
  group UsbPeri_usbfp
    ../source/UsbPeri/USBFp/: avoid_link_float.s usbfphal.c usbfp.c
