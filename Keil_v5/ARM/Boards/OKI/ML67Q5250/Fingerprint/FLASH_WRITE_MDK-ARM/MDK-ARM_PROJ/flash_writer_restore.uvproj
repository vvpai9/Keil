# Keil uVision project flash_writer_restore.uvproj, settings and files
target flash_writer_restore (ARM-ADS)
  device: ML67Q5250 OKI
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: flash_data.hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
