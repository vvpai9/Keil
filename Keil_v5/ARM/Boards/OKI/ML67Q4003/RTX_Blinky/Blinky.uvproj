# Keil uVision project Blinky.uvproj, settings and files
target ML67Q4003 (ARM-ADS)
  device: ML674003 OKI
  cpu: IRAM(0x10000000-0x10007FFF) IROM(0xC8000000-0xC807FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT7: RAM 0xd0000000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c ML674K.s
  group Documentation
    ./: Abstract.txt
