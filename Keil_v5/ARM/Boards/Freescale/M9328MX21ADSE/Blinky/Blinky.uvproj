# Keil uVision project Blinky.uvproj, settings and files
target i.MX21 Int RAM (ARM-ADS)
  device: MC9328MX21 Freescale Semiconductor
  cpu: IRAM(0xFFFFE800-0xFFFFFFFF) IROM(0x0-0x5FFF) CLOCK(32768) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: RAM_HADR
  library: MicroLIB
  memory RVCT4: ROM 0xffffe800 size 0x1000
  memory RVCT9: RAM 0xfffff800 size 0x800
  group Startup Code
    ./: iMX21.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target i.MX21 Ext NOR (ARM-ADS)
  device: MC9328MX21 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xc8000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT6: RAM 0xc0000000 size 0x4000000
  memory RVCT9: RAM 0xffffe800 size 0x1800
