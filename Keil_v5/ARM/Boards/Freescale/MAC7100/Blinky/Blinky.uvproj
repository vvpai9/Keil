# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: MAC7111 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0x0-0x87FFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: MAC71xx.s
  group Retarget
    ./: Retarget.c
  group Interrupts
    ./: IRQ.c
  group Source
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target MAC7100 Board - Flash (ARM-ADS)
  device: MAC7111 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
target MAC7100 Board - RAM (ARM-ADS)
  device: MAC7111 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: RAM_MODE
  memory RVCT4: ROM 0x40000000 size 0x4000
  memory RVCT9: RAM 0x40004000 size 0x4000
