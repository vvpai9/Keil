# Keil uVision project easyweb.uvproj, settings and files
target Star9 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x87FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: easyweb
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Startup Code
    ./: STR91x.s
  group Source Code
    ./: easyweb.c tcpip.c ENET.c Retarget.c
  group HTML Code
    ./: webpage.html
  group Documentation
    ./: Abstract.txt
