# Keil uVision project Blinky.uvproj, settings and files
target PC7230 Ext SDRAM (ARM-ADS)
  device: PC7230 Socle Technology Corp.
  cpu: CLOCK(12000000) CPUTYPE(ARM7EJ-S)
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 231,47,1295
  c include: c:\Keil\ARM\INC\Socle\lib\;c:\Keil\ARM\INC\Socle\platform\PDK_PC72xx\
  asm define: CLOCK_NO_INIT MC_NO_INIT REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  group Startup Code
    ./: PC72xx.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target PC7230 Ext NOR (ARM-ADS)
  device: PC7230 Socle Technology Corp.
  cpu: CLOCK(12000000) CPUTYPE(ARM7EJ-S)
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 231,47,1295
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x80000000 size 0x4000000
