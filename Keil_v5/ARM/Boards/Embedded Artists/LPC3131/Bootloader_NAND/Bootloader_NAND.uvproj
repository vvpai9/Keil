# Keil uVision project Bootloader_NAND.uvproj, settings and files
target LPC31xx NAND Bootloader (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: LPC31xx_NAND_BL
  c flags: Optim=1
  asm define: BOOT_HEADER SIZE_INT_INFO
  library: MicroLIB
  memory RVCT4: ROM 0x11029000 size 0xef80
  memory RVCT9: RAM 0x11038000 size 0x8000
  memory RVCT10: RAM 0x11040000 size 0x18000
  group Bootloader Code
    ./: LPC31xx.s Bootloader.c FlashHW.c
  group Documentation
    ./: Abstract.txt
