# Keil uVision project Blinky.uvproj, settings and files
target LPC3141 Ext SDRAM (ARM-ADS)
  device: LPC3141 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO NO_CLOCK_INIT NO_MPMC_INIT
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x2000000
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT6: RAM 0x32000000 size 0x2000000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  group Startup Code
    ./: LPC31xx.s
  group Source Code
    ./: Blinky.c IRQ.c
  group Documentation
    ./: Abstract.txt
