# Keil uVision project Blinky.uvproj, settings and files
target BU1511KV2-EB (ARM-ADS)
  device: BU1511KV2 ROHM
  cpu: IRAM(0x10000000-0x1003FFFF) IROM(0x0000000-0x003FFFFF) CLOCK(13500000) CPUTYPE(ARM946E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x40000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c startup_BU1511KV2.s
  group Documentation
    ./: Abstract.txt
