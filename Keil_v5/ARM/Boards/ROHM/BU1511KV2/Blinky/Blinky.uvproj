# Keil uVision project Blinky.uvproj, settings and files
target Ext. Flash (ARM-ADS)
  device: BU1511KV2 ROHM
  cpu: IRAM(0x10000000-0x1003FFFF) IROM(0x0000000-0x003FFFFF) CLOCK(13500000) CPUTYPE(ARM946E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x40000
  group System Files
    ./: startup_BU1511KV2.s IRQSYS.s IRQ.c
  group Source Files
    ./: Retarget.c Serial.c Timer.c Blinky.c
  group Documentation
    ./: Abstract.txt
target Ext. RAM (ARM-ADS)
  device: BU1511KV2 ROHM
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x800
  memory RVCT9: RAM 0x10000800 size 0x800
target TCM Cache (ARM-ADS)
  device: BU1511KV2 ROHM
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x800
