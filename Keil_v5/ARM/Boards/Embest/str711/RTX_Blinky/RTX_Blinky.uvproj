# Keil uVision project RTX_Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR711FR2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: Blinky.c
  group Library
    ../../../../RV31/LIB/ST/: STR71x.LIB
  group Configuration
    ./: RTX_Config.c STR71x.s
  group Documentation
    ./: Abstract.txt
target STR711 (ARM-ADS)
  device: STR711FR2 STMicroelectronics
  cpu: as above
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
