# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR911FM44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x87FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Startup Code
    ./: STR91x.s
  group Interrupts
    ./: 91x_it.c
  group Library
    ../../../../RV31/LIB/ST/: STR91xR.LIB
  group Source
    ./: main.c
  group Documentation
    ./: Readme.txt
target STR912 (ARM-ADS)
  device: STR911FM44 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
