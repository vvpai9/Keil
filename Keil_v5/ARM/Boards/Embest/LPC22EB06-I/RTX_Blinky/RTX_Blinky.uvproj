# Keil uVision project RTX_Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2292 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c Startup.s
  group Documentation
    ./: Abstract.txt
target LPC22EB06-I (ARM-ADS)
  device: LPC2292 NXP (founded by Philips)
  cpu: as above
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
