# Keil uVision project RTX_Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Blinky.c
  group Configuration
    ./: Startup.s RTX_Config.c
  group Documentation
    ./: Abstract.txt
target LPCEB2000-A (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: as above
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
