# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7S64 Atmel
  cpu: IRAM(0x200000-0x203FFF) IROM(0x100000-0x10FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x200000 size 0x4000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c SAM7.s
  group Documentation
    ./: Abstract.txt
target AT91SAM7S (ARM-ADS)
  device: AT91SAM7S64 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x200000 size 0x4000
