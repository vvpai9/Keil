# Keil uVision project RTX_Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group Source
    ./: Blinky.c
  group Library
    ../../../../RV31/LIB/ST/: STR73x.LIB
  group Configuration
    ./: RTX_Config.c STR73x.s
  group Documentation
    ./: Abstract.txt
target STR730 (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: RTX_Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
