# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group startup code
    ./: STR75x.s
  group interrupts
    ./: 75x_it.c
  group Library
    ../../../../RV31/LIB/ST/: STR75xR.LIB
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target STR750 (ARM-ADS)
  device: STR750FV2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
