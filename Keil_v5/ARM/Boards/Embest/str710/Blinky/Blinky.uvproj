# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STR71x.s
  group Interrupts
    ./: 71x_it.c
  group Library
    ../../../../RV31/LIB/ST/: STR71xR.LIB
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target STR710 (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
