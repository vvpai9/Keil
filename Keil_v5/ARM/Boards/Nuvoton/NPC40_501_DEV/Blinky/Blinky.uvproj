# Keil uVision project Blinky.uvproj, settings and files
target NUC501 SPI ROM (ARM-ADS)
  device: NUV501BDN Nuvoton
  cpu: IROM (0x40000000-0x401FFFFF) IRAM(0x00000100-0x00007FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x40000000 size 0x200000
  memory RVCT9: RAM 0x100 size 0x7f00
  group System Files
    ./: startup_NUC501.s IRQSYS.s IRQ.c
  group Source Files
    ./: Retarget.c Serial.c Timer.c Blinky.c
  group Documentation
    ./: Abstract.txt
target NUC501 ROM (ARM-ADS)
  device: NUV501BDN Nuvoton
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x4000 size 0x4000
target NUC501 SRAM (ARM-ADS)
  device: NUV501BDN Nuvoton
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x4000 size 0x4000
