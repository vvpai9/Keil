# Keil uVision project Blinky.uvproj, settings and files
target TMPA910 Int RAM (ARM-ADS)
  device: TMPA910CRAXBG Toshiba
  cpu: IRAM(0xF8002000-0xF800FFFF) IROM(0x0-0x3FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: REMAP
  library: MicroLIB
  memory RVCT4: ROM 0xf8002000 size 0xc000
  memory RVCT9: RAM 0xf800e000 size 0x2000
  group Startup Code
    ./: TMPA910.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target TMPA910 Ext NOR (ARM-ADS)
  device: TMPA910CRAXBG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0xe000
