# Keil uVision project Blinky.uvproj, settings and files
target TMPA900 Int RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) IROM(0x0-0x3FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: REMAP
  library: MicroLIB
  memory RVCT4: ROM 0xf8002000 size 0x4000
  memory RVCT9: RAM 0xf8006000 size 0x4000
  group Startup Code
    ./: TMPA900.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target TMPA900 Ext NOR (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
target TMPA900 Ext RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: REMAP, MPMC0_NO_INIT
  library: MicroLIB
  memory RVCT1: ROM 0x40000000 size 0x100000
  memory RVCT4: ROM 0xf8002000 size 0x2000
  memory RVCT6: RAM 0x40100000 size 0x100000
  memory RVCT9: RAM 0xf8004000 size 0x4000
  memory RVCT10: RAM 0xf8008000 size 0x2000
