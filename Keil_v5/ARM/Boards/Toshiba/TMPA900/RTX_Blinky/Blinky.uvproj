# Keil uVision project Blinky.uvproj, settings and files
target TMPA900 Int RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) IROM(0x0-0x3FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=4
  asm define: REMAP
  library: MicroLIB
  memory RVCT4: ROM 0xf8002000 size 0x4000
  memory RVCT9: RAM 0xf8006000 size 0x4000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c TMPA900.s
  group Documentation
    ./: Abstract.txt
