# Keil uVision project Hello.uvproj, settings and files
target S3C44001 Board (ARM-ADS)
  device: S3C44B0X Samsung
  cpu: IRAM(0x10000000-0x10001FFF) CLOCK(66000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x400000
  memory RVCT6: RAM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup Code
    ./: S3C44B0X.s
  group System Calls
    ./: Retarget.c Serial.c Time.c
  group Source Code
    ./: Hello.c
  group Documentation
    ./: Abstract.txt
