# Keil uVision project Blinky.uvproj, settings and files
target S3F4A0K Flash (ARM-ADS)
  device: S3F4A0KR Samsung
  cpu: IRAM(0x300000-0x307FFF) IROM(0-0xFFFFF) IROM1(0x80000000-0x80007FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c misc: --diag_suppress 815
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x300000 size 0x8000
  group Startup Code
    ./: S3F4A.s
  group Library
    C:/Keil/ARM/RV31/LIB/Samsung/: S3F4A.LIB
  group Source Code
    ./: IRQ.c Blinky.c
  group Documentation
    ./: Abstract.txt
