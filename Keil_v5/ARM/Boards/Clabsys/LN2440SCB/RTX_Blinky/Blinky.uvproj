# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Blinky
  c flags: Optim=4
  asm define: RAM_INTVEC
  asm misc: --pd "__RTX SETA 1"
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c S3C2440.s
  group Documentation
    ./: Abstract.txt
target S3C2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Blinky
  c flags: Optim=4
  asm define: RAM_INTVEC
  asm misc: --pd "__RTX SETA 1"
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
