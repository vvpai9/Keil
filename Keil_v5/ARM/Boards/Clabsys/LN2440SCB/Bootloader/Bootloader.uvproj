# Keil uVision project Bootloader.uvproj, settings and files
target S3C2440 NAND Bootloader (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: S3C2440_NAND_Bootloader
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xd00
  memory RVCT9: RAM 0x40000d00 size 0x300
  group Bootloader Code
    ./: S3C2440.s Bootloader.c FlashHW.c
  group Documentation
    ./: Abstract.txt
