# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Blinky
  c flags: Optim=1
  asm define: RAM_INTVEC
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Startup Code
    ./: S3C2440.s
  group Source
    ./: Blinky.c IRQ.c
  group Documentation
    ./: Abstract.txt
target S3C2440 Ext SDRAM (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Blinky
  c flags: Optim=1
  asm define: RAM_INTVEC
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
