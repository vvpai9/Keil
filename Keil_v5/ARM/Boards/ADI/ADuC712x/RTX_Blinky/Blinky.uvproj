# Keil uVision project Blinky.uvproj, settings and files
target ADuC712x (ARM-ADS)
  device: ADuC7128 Analog Devices
  cpu: IRAM(0x40000-0x41FFF) IROM(0x80000-0x9F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1f800
  memory RVCT9: RAM 0x40000 size 0x2000
  group Source
    ./: Blinky.c
  group Configuration
    ./: RTX_Config.c ADuC712x.s
  group Documentation
    ./: Abstract.txt
