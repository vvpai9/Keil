# Keil uVision project CBlinky.uvproj, settings and files
target ADuC7128 (ARM-ADS)
  device: ADuC7128 Analog Devices
  cpu: IRAM(0x40000-0x41FFF) IROM(0x80000-0x9F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: CBlinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1f800
  memory RVCT9: RAM 0x40000 size 0x2000
  group Startup Code
    ./: ADuC712x.s
  group Source Code
    ./: main.c Retarget.c
    ../../../../INC/ADI/: irq_arm.c
