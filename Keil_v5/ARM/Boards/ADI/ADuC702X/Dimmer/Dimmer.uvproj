# Keil uVision project Dimmer.uvproj, settings and files
target Simulator (ARM-ADS)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: Dimmer
  c flags: Optim=1
  c define: __KEIL__
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x20000
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Dimmer.c IRQ.c
  group Documentation
    ./: Abstract.txt
target ADuC7026 (ARM-ADS)
  device: ADuC7026 Analog Devices
  cpu: as above
  output: Dimmer
  c flags: Optim=1
  c define: __KEIL__
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x20000
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
target ADuC7026 + Ext. Flash (ARM-ADS)
  device: ADuC7026 Analog Devices
  cpu: as above
  output: Dimmer
  c flags: Optim=1
  c define: __KEIL__
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x20000
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  scatter file: .\ExtFlash.sct
