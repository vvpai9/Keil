# Keil uVision project Blinky.uvproj, settings and files
target ADuC7024 Flash (ARM-ADS)
  device: ADuC7024 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  c define: P42LED_ONLY
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Blinky.c
target Simulator (ARM-ADS)
  device: ADuC7024 Analog Devices
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: P42LED_ONLY
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
