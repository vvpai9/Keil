# Keil uVision project Demo.uvproj, settings and files
target STR73x Eval Board (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: Demo
  c flags: Optim=1
  c misc: --diag_suppress 951
  c include: INC
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group Startup Code
    ./SRC/: STR73x.s
  group Source Code
    ./SRC/: 73x_it.c boardtest.c buzzer.c i2c_ee.c lcd.c leds.c lowpower.c main.c menu.c periodmeasure.c spi_ee.c temperature.c timesetting.c
  group Standard Library
    ../../../../RV31/LIB/ST/: STR73xR.LIB
