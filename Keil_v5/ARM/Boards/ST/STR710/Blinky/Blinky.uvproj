# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x400000
  memory RVCT4: ROM 0x40000000 size 0x30000
  memory RVCT5: ROM 0x40030000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STR71x.s
  group Interrupts
    ./: IRQ.c
  group Retarget
    ./: Retarget.c
  group Library
    ../../../../RV31/LIB/ST/: STR71x.LIB
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target STR710 Board Flash (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x400000
  memory RVCT4: ROM 0x40000000 size 0x30000
  memory RVCT5: ROM 0x40030000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STR710 Board RAM (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x400000
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target STR710 Board ExtMem (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x3f0000
  memory RVCT2: ROM 0x603f0000 size 0x10000
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
