# Keil uVision project Joystick.uvproj, settings and files
target STR750 Eval Board (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Joystick
  c flags: Optim=1
  c include: C:\Keil\ARM\INC\ST\75x\USB;.\INC
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./SRC/: STR75x.s
  group Source Code
    ./SRC/: 75x_it.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Standard Library
    ../../../../RV31/LIB/ST/: STR75xR.LIB
  group USB Library
    C:/Keil/ARM/RV31/LIB/ST/STR75x/USB/: usb_core.c usb_init.c usb_int.c usb_regs.c
  group Documentation
    ./: Readme.txt
