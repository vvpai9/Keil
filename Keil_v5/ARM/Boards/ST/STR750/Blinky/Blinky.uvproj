# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x30000
  memory RVCT5: ROM 0x20030000 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: STR75x.s
  group Interrupts
    ./: IRQ.c
  group Retarget
    ./: Retarget.c
  group Source Code
    ./: Blinky.c GLCD.c Font5x7.c
  group Documentation
    ./: Abstract.txt
target STR750 Flash (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x30000
  memory RVCT5: ROM 0x20030000 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x4000
target STR750 RAM (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x2000
  memory RVCT9: RAM 0x40002000 size 0x2000
