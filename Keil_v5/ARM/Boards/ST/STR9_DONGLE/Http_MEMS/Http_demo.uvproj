# Keil uVision project Http_demo.uvproj, settings and files
target STR9 Dongle (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi tcp.cgi tcp_header.inc tcp_footer.inc system.cgi language.cgi mems.cgi
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c 91x_mems.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c RTX_Config.c STR91x_RTX.s STR91x.s
  group Library
    ./: STR9_ENET.c
    ../../../../RV31/LIB/: TCP_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target STR9 Dongle RTX (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
