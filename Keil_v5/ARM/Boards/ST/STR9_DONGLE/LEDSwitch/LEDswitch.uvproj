# Keil uVision project LEDswitch.uvproj, settings and files
target STR9 Dongle (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: LEDswitch
  c flags: Optim=1
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Source Files
    ./: LEDSwitch.c
  group Configuration Files
    ./: Net_Config.c STR91x.s
  group Library
    ./: STR9_ENET.c
    ../../../../RV31/LIB/: TCP_ARM_L.lib
  group Documentation
    ./: Abstract.txt
