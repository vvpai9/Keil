# Keil uVision project Demo.uvproj, settings and files
target STR910 Eval Board (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Demo
  c flags: Optim=1
  c define: _ENET
  c misc: --diag_suppress 951
  c include: C:\Keil\ARM\INC\ST\91x\USB;.\INC;.\UIP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Startup Code
    ./SRC/: STR91x.s
  group Source Code
    ./SRC/: 91x_it.c main.c can.c lcd.c menu.c calendar.c joystickHID.c waveplayer.c webserver.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group UIP Code
    ./UIP/: uIPMain.c uip.c uip_arch.c uip_arp.c fs.c cgi.c httpd.c
  group Standard Library
    C:/Keil/ARM/RV31/LIB/ST/STR91x/: memcopy.s 91x_enet.c
    C:/Keil/ARM/RV31/LIB/ST/: STR91xR.LIB
  group USB Library
    C:/Keil/ARM/RV31/LIB/ST/STR91x/USB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
