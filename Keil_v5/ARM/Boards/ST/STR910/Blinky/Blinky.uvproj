# Keil uVision project Blinky.uvproj, settings and files
target STR910 Flash (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group Startup Code
    ./: STR91x.s
  group Retarget
    ./: Retarget.c
  group Source
    ./: Blinky.c GLCD.c Font5x7.c
  group Documentation
    ./: Abstract.txt
target STR910 RAM (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x4000000 size 0x8000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4008000 size 0x8000
