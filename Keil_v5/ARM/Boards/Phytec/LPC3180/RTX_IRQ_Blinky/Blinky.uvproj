# Keil uVision project Blinky.uvproj, settings and files
target LPC3180 Ext SDRAM (ARM-ADS)
  device: LPC3180 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0800FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x81000000 size 0x1000000
  memory RVCT9: RAM 0x8000000 size 0x10000
  group Startup Code
    ./: LPC3000.s
  group RTX Configuration
    ./: RTX_Config.c
  group Interrupts
    ./: IRQ.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
