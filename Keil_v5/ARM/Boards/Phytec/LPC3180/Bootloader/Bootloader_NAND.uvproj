# Keil uVision project Bootloader_NAND.uvproj, settings and files
target LPC3180 NAND Bootloader (ARM-ADS)
  device: LPC3180 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0800FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: LPC3180_NAND_Bootloader
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e00
  memory RVCT9: RAM 0x8003e00 size 0x200
  link misc: --entry 0
  group Bootloader Code
    ./: LPC3000.s Bootloader.c FlashHW.c
  group Documentation
    ./: Abstract.txt
