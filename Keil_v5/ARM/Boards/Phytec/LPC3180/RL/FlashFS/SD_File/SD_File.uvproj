# Keil uVision project SD_File.uvproj, settings and files
target LPC3180 (ARM-ADS)
  device: LPC3180 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0800FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: SD_File
  c flags: Optim=4
  asm define: SIZE_EXT_INFO RAM_INTVEC REMAP
  memory RVCT1: ROM 0x80000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x81000000 size 0x1000000
  memory RVCT9: RAM 0x8000000 size 0x10000
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: File_Config.c MCI_LPC3xxx.c LPC3000.s
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
