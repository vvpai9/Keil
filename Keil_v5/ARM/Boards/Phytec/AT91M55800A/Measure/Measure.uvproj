# Keil uVision project Measure.uvproj, settings and files
target Simulator AT91M55800A (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Measure
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1000000 size 0x400000
  memory RVCT6: RAM 0x4000000 size 0x80000
  memory RVCT9: RAM 0x20 size 0x1fe0
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Measure.c Mcommand.c Getline.c
  group Documentation
    ./: Abstract.txt
target phyXRAM AT91M55800A (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Measure
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x4000000 size 0x80000
  memory RVCT9: RAM 0x20 size 0x1fe0
target phyFlash AT91M55800A (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: Measure
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x1000000 size 0x400000
  memory RVCT6: RAM 0x4000000 size 0x80000
  memory RVCT9: RAM 0x20 size 0x1fe0
