# Keil uVision project easyweb.uvproj, settings and files
target phyCore LPC229x - Flash (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: easyweb
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group HTML Source
    ./: webpage.html
  group C Source Files
    ./: easyweb.c tcpip.c LAN91C111.c Retarget.c
  group Configuration Files
    ./: Startup.s Flash.ini XRAM.ini tcpip.h
  group Documentation
    ./: Abstract.txt
target phyCore LPC229x - XRAM (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: easyweb
  c flags: Optim=4
  library: MicroLIB
  memory RVCT1: ROM 0x81000000 size 0x80000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81080000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x4000
