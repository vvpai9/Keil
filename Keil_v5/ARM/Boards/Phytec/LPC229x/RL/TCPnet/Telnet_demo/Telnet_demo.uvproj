# Keil uVision project Telnet_demo.uvproj, settings and files
target LPC229x (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c Startup.s Flash.ini
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: Lan91C111.c
  group Documentation
    ./: Abstract.txt
target LPC229x Debug (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x4000
