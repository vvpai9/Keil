# Keil uVision project Http_demo.uvproj, settings and files
target LPC229x (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi tcp.cgi system.cgi language.cgi buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c Startup.s Startup_RTX.s Flash.ini
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: Lan91C111.c
  group Documentation
    ./: Abstract.txt
target LPC229x Debug (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x4000
target LPC229x RTX (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x200000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x81000000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x4000
