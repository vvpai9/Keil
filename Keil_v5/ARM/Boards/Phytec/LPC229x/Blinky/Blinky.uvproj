# Keil uVision project Blinky.uvproj, settings and files
target phyCore LPC229x Simulator (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x400000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Blinky.c Time.c
  group Documentation
    ./: Abstract.txt
target phyCore LPC229x IntFlash (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
target phyCore LPC229x ExtFlash (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x400000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
target phyCore LPC229x IntRam (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0x0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x2000
  memory RVCT9: RAM 0x40002000 size 0x2000
target phycore LPC229x ExtRAM (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x81000000 size 0x40000
  memory RVCT9: RAM 0x40000100 size 0x3f00
