# Keil uVision project Hello.uvproj, settings and files
target phyCore LPC229x (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x400000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Hello.c Serial.c
  group Documentation
    ./: Abstract.txt
target Simulator LPC229x (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: Hello
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x400000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
