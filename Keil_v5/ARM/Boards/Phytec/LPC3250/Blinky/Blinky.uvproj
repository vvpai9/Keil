# Keil uVision project Blinky.uvproj, settings and files
target LPC3250 Int RAM (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: Blinky
  c flags: Optim=1
  asm define: REMAP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT5: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x8020000 size 0x20000
  group Startup Code
    ./: LPC32x0.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC3250 Ext SDRAM (NOR) (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
target LPC3250 Ext SDRAM (NAND) (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
