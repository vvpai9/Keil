# Keil uVision project Blinky.uvproj, settings and files
target LPC3250 Ext SDRAM (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: Blinky
  c flags: Optim=4
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x81000000 size 0x1000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group Startup Code
    ./: LPC32x0.s
  group RTX Configuration
    ./: RTX_Config.c
  group Interrupts
    ./: IRQ.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
