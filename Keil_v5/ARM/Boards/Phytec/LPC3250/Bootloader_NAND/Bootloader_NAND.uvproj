# Keil uVision project Bootloader_NAND.uvproj, settings and files
target LPC3000 NAND Bootloader (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: LPC3000_NAND_Bootloader
  c flags: Optim=1
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e00
  memory RVCT9: RAM 0x8003e00 size 0x200
  link misc: --entry 0
  group Bootloader Code
    ./: LPC32x0.s Bootloader.c FlashHW.c
  group Documentation
    ./: Abstract.txt
