# Keil uVision project easyweb.uvproj, settings and files
target LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: easyweb
  c flags: Optim=4
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group HTML Source
    ./: webpage.html
  group C Source Files
    ./: easyweb.c tcpip.c EMAC.c
  group Configuration Files
    ./: tcpip.h LPC32x0.s
  group Documentation
    ./: Abstract.txt
