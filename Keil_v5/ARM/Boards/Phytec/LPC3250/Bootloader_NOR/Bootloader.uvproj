# Keil uVision project Bootloader.uvproj, settings and files
target LPC32x0 NOR Bootloader (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: LPC32x0_NOR_Bootloader
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0xe0000000 size 0x8000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group Bootloader Code
    ./: LPC32x0.s Bootloader.c FlashHW.c
  group Documentation
    ./: Abstract.txt
