# Keil uVision project Http_demo.uvproj, settings and files
target LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi tcp.cgi system.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c LPC32x0.s LPC32x0_RTX.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: LPC32_EMAC.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LPC3250 Debug (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c define: DEBUG
  c include: ..\Library
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
target LPC3250 RTX (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
