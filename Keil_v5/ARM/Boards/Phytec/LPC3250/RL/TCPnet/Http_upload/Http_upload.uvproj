# Keil uVision project Http_upload.uvproj, settings and files
target LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: Http_upload
  c flags: Optim=4
  c include: ..\Library
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group HTTP Files
    ./Web/: Web.inp index.htm upload.cgi dir.cgi format.cgi pg_header.inc pg_footer.inc
  group Source Files
    ./: HTTP_upload.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c File_Config.c HTTP_uif.c Retarget.c LPC32x0.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib FS_ARM_L.lib
    ../Library/: LPC32_EMAC.c IRQ.c
    ./: MCI_LPC3xxx.c
  group Documentation
    ./: Abstract.txt
