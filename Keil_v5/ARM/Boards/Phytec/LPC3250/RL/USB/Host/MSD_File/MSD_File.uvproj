# Keil uVision project MSD_File.uvproj, settings and files
target Phytec LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: MSD_File
  c flags: Optim=4
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group Startup
    ./: LPC32x0.s
  group Configuration
    ./: File_Config.c usb_config.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c IRQ.c Getline.c Serial.c fs_usbh_msc.c usbh_ohci_lpc32x0.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib USB_ARM_L.lib
  group Documentation
    ./: Abstract.txt
