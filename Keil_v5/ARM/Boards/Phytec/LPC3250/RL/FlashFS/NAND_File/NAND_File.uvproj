# Keil uVision project NAND_File.uvproj, settings and files
target LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: NAND_File
  c flags: Optim=4
  asm define: SIZE_EXT_INFO EMC_NO_INIT RAM_INTVEC REMAP
  memory RVCT1: ROM 0x80000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x82000000 size 0x2000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group Source Files
    ./: Getline.c NAND_File.c
  group Configuration Files
    ./: File_Config.c LPC32x0.s NAND_LPC32xx.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
