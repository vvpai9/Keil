# Keil uVision project Bootloader_NAND.uvproj, settings and files
target i.MX27 NAND Bootloader (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: IRAM(0xFFFF4C00-0xFFFFFFFF) IROM(0x0-0x3FFF) CLOCK(26000000) CPUTYPE(ARM926EJ-S) EBIG
  output: iMX27_NAND_Bootloader
  AfterMake: fromelf --i32 --output .\Output\iMX27_NAND_Bootloader.hex .\Output\iMX27_NAND_Bootloader.axf
  c flags: Optim=4 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0xd8000000 size 0x800
  memory RVCT9: RAM 0xffff4c00 size 0xb400
  scatter file: .\Main_in_RAM.sct
  group Bootloader Code
    ./: iMX27.s Bootloader.c FlashHW.c
  group Documentation
    ./: Abstract.txt
