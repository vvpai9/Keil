# Keil uVision project Http_demo.uvproj, settings and files
target MCIMX27 (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: IRAM(0xFFFF4C00-0xFFFFFFFF) IROM(0x0-0x3FFF) CLOCK(26000000) CPUTYPE(ARM926EJ-S)
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  asm define: WEIM_NO_INIT RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0xa0000000 size 0x8000000
  memory RVCT9: RAM 0xffff4c00 size 0xb400
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi leds.cgi tcp.cgi system.cgi language.cgi pg_header.inc pg_footer.inc
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c iMX27.s iMX27_RTX.s
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib TCPD_ARM_L.lib
    ../Library/: FEC_IMX27.c IRQ.c
  group Documentation
    ./: Abstract.txt
target MCIMX27 Debug (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c define: DEBUG
  c include: ..\Library
  asm define: WEIM_NO_INIT RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0xa0000000 size 0x8000000
  memory RVCT9: RAM 0xffff4c00 size 0xb400
target MCIMX27 RTX (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  asm define: WEIM_NO_INIT RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0xa0000000 size 0x8000000
  memory RVCT9: RAM 0xffff4c00 size 0xb400
