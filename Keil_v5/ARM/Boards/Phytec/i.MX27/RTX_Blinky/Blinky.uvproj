# Keil uVision project Blinky.uvproj, settings and files
target MCIMX27 Ext NOR (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: IRAM(0xFFFF4C00-0xFFFFFFFF) IROM(0x0-0x3FFF) CLOCK(26000000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1
  asm define: WEIM_NO_INIT RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0xa0000000 size 0x8000000
  memory RVCT9: RAM 0xffff4c00 size 0xb2f0
  group Startup Code
    ./: iMX27.s
  group RTX Configuration
    ./: RTX_Config.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
