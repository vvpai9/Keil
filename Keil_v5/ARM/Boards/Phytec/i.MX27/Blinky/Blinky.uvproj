# Keil uVision project Blinky.uvproj, settings and files
target MCIMX27 Int RAM (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: IRAM(0xFFFF4C00-0xFFFFFFFF) IROM(0x0-0x3FFF) CLOCK(26000000) CPUTYPE(ARM926EJ-S) EBIG
  output: Blinky
  c flags: Optim=1
  asm define: RAM_HADR
  library: MicroLIB
  memory RVCT4: ROM 0xffff4c00 size 0x7800
  memory RVCT9: RAM 0xffffc400 size 0x3af0
  group Startup Code
    ./: iMX27.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target MCIMX27 Ext NOR (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: WEIM_NO_INIT RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0xa0000000 size 0x8000000
  memory RVCT9: RAM 0xffff4c00 size 0xb2f0
target MCIMX27 Ext SDRAM (NAND) (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: SIZE_INFO CLOCK_NO_INIT ESDRAMC_NO_INIT RAM_HADR
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x4000000
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0xa4000000 size 0x4000000
  memory RVCT9: RAM 0xffff4c00 size 0xb2f0
target Download NAND Bootloader (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: as above
  output: iMX27_NAND_Bootloader.hex +hex
  library: MicroLIB
  memory RVCT4: ROM 0xd8000000 size 0x800
  memory RVCT9: RAM 0xffff4c00 size 0xb400
