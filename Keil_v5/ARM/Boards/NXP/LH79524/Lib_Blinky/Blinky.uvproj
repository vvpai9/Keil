# Keil uVision project Blinky.uvproj, settings and files
target LH79524 Int RAM (ARM-ADS)
  device: LH79524 NXP (founded by Philips)
  cpu: IRAM(0x60000000-0x60003FFF) CLOCK(11289600) CPUTYPE(ARM720T)
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 68
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x2000
  memory RVCT9: RAM 0x60002000 size 0x2000
  group Startup Code
    ./: LH79524.s
  group Library
    C:/Keil/ARM/RV31/LIB/NXP/: LH79524.LIB
  group Source Code
    ./: Blinky.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LH79524 Ext NOR Flash (ARM-ADS)
  device: LH79524 NXP (founded by Philips)
  cpu: IRAM(0x60000000-0x60003FFF) CLOCK(11289600) CPUTYPE(ARM720T)
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 68
  asm define: REMAP EXTSRAM1_MODE
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x1000000
  memory RVCT4: ROM 0x44000000 size 0x1000000
  memory RVCT6: RAM 0x21000000 size 0x1000000
  memory RVCT9: RAM 0x60000000 size 0x4000
target LH79524 Ext SDRAM (ARM-ADS)
  device: LH79524 NXP (founded by Philips)
  cpu: IRAM(0x60000000-0x60003FFF) CLOCK(11289600) CPUTYPE(ARM720T)
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 68
  asm define: EMC_DYN_NOINIT
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x1000000
  memory RVCT6: RAM 0x21000000 size 0x1000000
  memory RVCT9: RAM 0x60000000 size 0x4000
