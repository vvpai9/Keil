# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: SJA2510HL/696 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x80013FFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0x14000
  group Startup Code
    ./: SJA2510.s
  group Source Code
    ./: Blinky.c IRQ.c
  group Documentation
    ./: Abstract.txt
target SJA2510 Flash (ARM-ADS)
  device: SJA2510HL/696 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0x14000
