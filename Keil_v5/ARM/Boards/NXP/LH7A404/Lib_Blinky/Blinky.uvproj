# Keil uVision project Blinky.uvproj, settings and files
target LH7A404 Int RAM (ARM-ADS)
  device: LH7A404 NXP (founded by Philips)
  cpu: IRAM(0xB0000000-0xB0013FFF) CLOCK(14745600) CPUTYPE(ARM922T)
  output: Blinky
  c flags: Optim=1
  asm define: INTSRAM_MODE
  library: MicroLIB
  memory RVCT4: ROM 0xb0000000 size 0x8000
  memory RVCT9: RAM 0xb0008000 size 0x7c00
  group Startup Code
    ./: LH7A40x.s
  group Library
    C:/Keil/ARM/RV31/LIB/NXP/: LH7A404.LIB
  group Source Code
    ./: Blinky.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LH7A404 Ext NOR Flash (ARM-ADS)
  device: LH7A404 NXP (founded by Philips)
  cpu: IRAM(0xB0000000-0xB0013FFF) CLOCK(14745600) CPUTYPE(ARM922T)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x1000000
  memory RVCT6: RAM 0xc0000000 size 0x4000000
  memory RVCT9: RAM 0xb0000000 size 0x14000
target LH7A404 Ext SDRAM (ARM-ADS)
  device: LH7A404 NXP (founded by Philips)
  cpu: IRAM(0xB0000000-0xB0013FFF) CLOCK(14745600) CPUTYPE(ARM922T)
  output: Blinky
  c flags: Optim=1
  asm define: SDMC_NOINIT EXTSDRAM_MODE
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x2000000
  memory RVCT6: RAM 0xc2000000 size 0x2000000
  memory RVCT9: RAM 0xb0000000 size 0x14000
