# Keil uVision project Simple.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2106 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0-0x1FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Simple
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x10000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Simple.c
target EVBA7 RAM (ARM-ADS)
  device: LPC2106 NXP (founded by Philips)
  cpu: as above
  output: Simple
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x8000
  memory RVCT9: RAM 0x40008000 size 0x8000
target EVBA7 Flash (ARM-ADS)
  device: LPC2106 NXP (founded by Philips)
  cpu: as above
  output: Simple
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x10000
