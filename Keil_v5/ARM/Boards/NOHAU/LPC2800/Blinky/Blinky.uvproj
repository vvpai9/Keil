# Keil uVision project Blinky.uvproj, settings and files
target LPC2888 Int RAM (ARM-ADS)
  device: LPC2888 NXP (founded by Philips)
  cpu: IRAM(0x400000-0x40FFFF) IROM(0x10400000-0x104FFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  asm define: NO_FLASHMARKER
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x408000 size 0x8000
  group Startup Code
    ./: LPC28xx.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC2888 Int Flash (ARM-ADS)
  device: LPC2888 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x10400000 size 0xff800
  memory RVCT5: ROM 0x104ff800 size 0x800
  memory RVCT9: RAM 0x400000 size 0x10000
