# Keil uVision project Memory.uvproj, settings and files
target LPC2800 Board (ARM-ADS)
  device: LPC2888 NXP (founded by Philips)
  cpu: IRAM(0x400000-0x40FFFF) IROM(0x10400000-0x104FFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x10400000 size 0xff800
  memory RVCT5: ROM 0x104ff800 size 0x800
  memory RVCT9: RAM 0x400000 size 0x10000
  group Startup Code
    ./: LPC28xx.s
  group Disk Image
    ./: DiskImg.c
  group Source Code
    ./: usbcfg.h usbhw.c usbcore.c usbdesc.c usbuser.c mscuser.c memory.c
  group Documentation
    ./: Abstract.txt
