# Keil uVision project Blinky.uvproj, settings and files
target TMS470R1B1M Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0xFFFFF) CLOCK(24000000) CPUTYPE(ARM7TDMI) EBIG
  output: Blinky
  c flags: Optim=1
  asm define: MEMORY_MAP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x40000000 size 0x400
  group Startup Code
    ./: TMS470R1B1M.s
  group RTX Configuration
    ./: RTX_Config.c
  group HET
    ./: HET.het HET.c
  group Source
    ./: Blinky.c IRQ.c LCD_4bit.c
  group Documentation
    ./: Abstract.txt
