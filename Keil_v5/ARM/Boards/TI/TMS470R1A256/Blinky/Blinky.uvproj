# Keil uVision project Blinky.uvproj, settings and files
target TMS470R1A256 Flash (ARM-ADS)
  device: TMS470R1A256 Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI) EBIG
  output: Blinky
  c flags: Optim=1
  asm define: MEMORY_MAP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Startup Code
    ./: TMS470R1Axxx.s
  group Source
    ./: Blinky.c SWI.s
  group RT Agent
    ./: RTA_Config.c
  group Documentation
    ./: Abstract.txt
target TMS470R1A256 RT_Agent (ARM-ADS)
  device: TMS470R1A256 Texas Instruments
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: RT_AGENT
  asm define: MEMORY_MAP SYS_MODE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
