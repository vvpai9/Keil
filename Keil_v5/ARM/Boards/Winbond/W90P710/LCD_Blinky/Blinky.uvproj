# Keil uVision project Blinky.uvproj, settings and files
target W90P710 Ext Boot Flash (ARM-ADS)
  device: W90P710 Winbond
  cpu: IRAM(0xFFE00000-0xFFE01FFF) ROM1(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x7f000000 size 0x1000000
  memory RVCT9: RAM 0xffe00000 size 0x2000
  group Startup Code
    ./: W90P710.s
  group Source Code
    ./: Blinky.c IRQ.c GLCD.c
  group Pictures
    ./: Background.c ARM_Ani.c
  group Documentation
    ./: Abstract.txt
target W90P710 Ext SDRAM (ARM-ADS)
  device: W90P710 Winbond
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 1
  asm define: EBI_NOINIT
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x800000 size 0x800000
  memory RVCT9: RAM 0xffe00000 size 0x2000
