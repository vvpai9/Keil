# Keil uVision project STR75xLIB.uvproj, settings and files
target STR75x Library - Keil style (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: STR75x (library)
  AfterMake: cmd.exe /C copy .\Output\STR75x.LIB ..\STR75x.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group ASM Source Files
    ./: Undef.s PAbt.s DAbt.s SWI.s FIQ.s IRQ.s
  group C Source Files
    ./: 75x_adc.c 75x_can.c 75x_cfg.c 75x_dma.c 75x_eic.c 75x_extit.c 75x_gpio.c 75x_i2c.c 75x_lib.c 75x_mrcc.c 75x_pwm.c 75x_rtc.c 75x_smi.c 75x_ssp.c 75x_tb.c 75x_tim.c 75x_uart.c 75x_wdg.c
target STR75x Library - Release (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: STR75xR (library)
  AfterMake: cmd.exe /C copy .\Release\STR75xR.LIB ..\STR75xR.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
target STR75x Library - Debug (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: STR75xD (library)
  AfterMake: cmd.exe /C copy .\Debug\STR75xD.LIB ..\STR75xD.LIB
  c flags: Optim=1 OneElfS=1
  c define: DEBUG
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
