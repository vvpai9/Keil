# Keil uVision project STR71xLIB.uvproj, settings and files
target STR71x Library - Keil style (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: STR71x (library)
  AfterMake: cmd.exe /C copy .\Output\STR71x.LIB ..\STR71x.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM Source Files
    ./: Undef.s PAbt.s DAbt.s SWI.s FIQ.s IRQ.s
  group C Source Files
    ./: 71x_lib.c adc12.c apb.c bspi.c can.c eic.c emi.c flash.c gpio.c i2c.c pcu.c rccu.c rtc.c tim.c uart.c wdg.c xti.c
target STR71x Library - Release (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: STR71xR (library)
  AfterMake: cmd.exe /C copy .\Release\STR71xR.LIB ..\STR71xR.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STR71x Library - Debug (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: STR71xD (library)
  AfterMake: cmd.exe /C copy .\Debug\STR71xD.LIB ..\STR71xD.LIB
  c flags: Optim=1 OneElfS=1
  c define: DEBUG
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
