# Keil uVision project STR73xLIB.uvproj, settings and files
target STR73x Library - Keil style (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: STR73x (library)
  AfterMake: cmd.exe /C copy .\Output\STR73x.LIB ..\STR73x.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group ASM Source Files
    ./: Undef.s PAbt.s DAbt.s SWI.s FIQ.s IRQ.s F_I_Bit.s
  group C Source Files
    ./: 73x_adc.c 73x_bspi.c 73x_can.c 73x_cfg.c 73x_cmu.c 73x_dma.c 73x_eic.c 73x_flash.c 73x_gpio.c 73x_i2c.c 73x_lib.c 73x_prccu.c 73x_pwm.c 73x_rtc.c 73x_tb.c 73x_tim.c 73x_uart.c 73x_wdg.c 73x_wiu.c 73x_wut.c
target STR73x Library - Release (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: STR73xR (library)
  AfterMake: cmd.exe /C copy .\Release\STR73xR.LIB ..\STR73xR.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
target STR73x Library - Debug (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: STR73xD (library)
  AfterMake: cmd.exe /C copy .\Debug\STR73xD.LIB ..\STR73xD.LIB
  c flags: Optim=1 OneElfS=1
  c define: DEBUG
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
