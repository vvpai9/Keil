# Keil uVision project STR91xLIB.uvproj, settings and files
target STR91x Library - Release (ARM-ADS)
  device: STR911FM44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x87FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: STR91xR (library)
  AfterMake: cmd.exe /C copy .\Release\STR91xR.LIB ..\STR91xR.LIB
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
  group ASM Source Files
    ./: Undef.s PAbt.s DAbt.s SWI.s FIQ.s IRQ.s
  group C Source Files
    ./: 91x_ahbapb.c 91x_adc.c 91x_can.c 91x_dma.c 91x_emi.c 91x_fmi.c 91x_gpio.c 91x_i2c.c 91x_lib.c 91x_MC.c 91x_rtc.c 91x_scu.c 91x_ssp.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c 91x_wiu.c
target STR91x Library - Debug (ARM-ADS)
  device: STR911FM44 STMicroelectronics
  cpu: as above
  output: STR91xD (library)
  AfterMake: cmd.exe /C copy .\Debug\STR91xD.LIB ..\STR91xD.LIB
  c flags: Optim=1 OneElfS=1
  c define: DEBUG
  memory RVCT4: ROM 0x0 size 0x88000
  memory RVCT9: RAM 0x4000000 size 0x18000
