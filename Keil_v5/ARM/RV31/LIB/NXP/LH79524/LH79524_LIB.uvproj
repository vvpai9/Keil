# Keil uVision project LH79524_LIB.uvproj, settings and files
target LH79524 Library (ARM-ADS)
  device: LH79524 NXP (founded by Philips)
  cpu: IRAM(0x60000000-0x60003FFF) CLOCK(11289600) CPUTYPE(ARM720T)
  output: LH79524 (library)
  AfterMake: cmd.exe /C copy .\Output\LH79524.LIB ..\LH79524.LIB
  c flags: Optim=4 OneElfS=1
  c misc: --diag_suppress 1296,111,260,550,3017
  library: MicroLIB
  memory RVCT4: ROM 0x44000000 size 0x1000000
  memory RVCT9: RAM 0x60000000 size 0x4000
  group ASM Source Files
    ./: lh79524_int_vec.s
  group C Source Files
    ./: lh79524_adc_driver.c lh79524_clcdc_driver.c lh79524_dma_driver.c lh79524_gpio_driver.c lh79524_i2s_driver.c lh79524_int_driver.c lh79524_mmu_driver.c lh79524_rtc_driver.c lh79524_ssp_driver.c lh79524_timer0_driver.c lh79524_timer_driver.c lh79524_uart_driver.c lh79524_wdt_driver.c
