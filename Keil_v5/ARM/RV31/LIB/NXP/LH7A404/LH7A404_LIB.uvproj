# Keil uVision project LH7A404_LIB.uvproj, settings and files
target LH7A404 Library (ARM-ADS)
  device: LH7A404 NXP (founded by Philips)
  cpu: IRAM(0xB0000000-0xB0013FFF) CLOCK(14745600) CPUTYPE(ARM922T)
  output: LH7A404 (library)
  AfterMake: cmd.exe /C copy .\Output\LH7A404.LIB ..\LH7A404.LIB
  c flags: Optim=4 OneElfS=1
  c define: __arm
  c misc: --diag_suppress 186,188
  library: MicroLIB
  memory RVCT9: RAM 0xb0000000 size 0x14000
  group ASM Source Files
    ./: lh7a404_vectors.s
  group C Source Files
    ./: lh7a404_ac97_driver.c lh7a404_adc_driver.c lh7a404_clcdc_driver.c lh7a404_csc_driver.c lh7a404_dcdc_driver.c lh7a404_dma_driver.c lh7a404_gpio_driver.c lh7a404_kmi_driver.c lh7a404_pwm_driver.c lh7a404_rtc_driver.c lh7a404_sdmmc_driver.c lh7a404_ssp_driver.c lh7a404_timer_driver.c lh7a404_uart_driver.c lh7a404_vic_driver.c lh7a404_wdt_driver.c sdk7a404_cf_driver.c sdk7a404_cf_fat.c sdk7a404_cpld_driver.c sdk7a404_strataflash.c lpc_arm922t_cp15_driver.c
