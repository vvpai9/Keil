# Keil uVision project LPC315x_LIB.uvproj, settings and files
target LPC315x Library (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: LPC315x (library)
  AfterMake: cmd.exe /C copy .\Output\LPC315x.LIB ..\LPC315x.LIB
  c flags: Optim=4 OneElfS=1
  c misc: --diag_suppress 3017
  library: MicroLIB
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  group ASM Source Files
    ./: lpc315x_vectors.s
  group C Source Files
    ./: lpc315x_adc10b_driver.c lpc315x_cgu_default.c lpc315x_cgu_driver.c lpc315x_crc_driver.c lpc315x_dma_driver.c lpc315x_evt_driver.c lpc315x_i2c_driver.c lpc315x_i2s_driver.c lpc315x_intc_driver.c lpc315x_ipint_driver.c lpc315x_mci_driver.c lpc315x_nand_driver.c lpc315x_otp_driver.c lpc315x_psu_driver.c lpc315x_pwm_driver.c lpc315x_rtc_driver.c lpc315x_spi_driver.c lpc315x_timer_driver.c lpc315x_uart_driver.c lpc315x_wdt_driver.c
