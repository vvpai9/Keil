# Keil uVision project S3F4A_LIB.uvproj, settings and files
target S3F4A Library (ARM-ADS)
  device: S3F4A0KR Samsung
  cpu: IRAM(0x300000-0x307FFF) IROM(0-0xFFFFF) IROM1(0x80000000-0x80007FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: S3F4A (library)
  AfterMake: cmd.exe /C copy .\Output\S3F4A.LIB ..\S3F4A.LIB
  c flags: Optim=4 OneElfS=1
  c misc: --diag_suppress 815,550
  asm misc: --diag_suppress A1608
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x300000 size 0x8000
  group C Source Files
    ./: csp.c csp_spurious.c csp_adc10.c csp_can.c csp_capt.c csp_cinit.c csp_dfc.c csp_epc.c csp_gic.c csp_gpt.c csp_i2c.c csp_ifc.c csp_ldma.c csp_pio.c csp_pwm.c csp_smc.c csp_spi.c csp_st16.c csp_stt.c csp_usart.c csp_wd.c
