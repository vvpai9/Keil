# Keil uVision project M28W320CB.uvproj, settings and files
target M28W320CB (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: M28W320CB
  AfterMake: cmd.exe /C copy M28W320CB.axf ..\M28W320CB.FLX
  c flags: Optim=3
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
