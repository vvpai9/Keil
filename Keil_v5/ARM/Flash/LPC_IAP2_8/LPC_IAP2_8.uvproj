# Keil uVision project LPC_IAP2_8.uvproj, settings and files
target LPC_IAP2_8 (ARM-ADS)
  device: LPC2101 Philips
  cpu: IRAM(0x40000000-0x400007FF) IROM(0-0x1FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC_IAP2_8
  AfterMake: cmd.exe /C copy LPC_IAP2_8.axf ..\LPC_IAP2_8.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x40000000 size 0x800
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: IAP.s FlashPrg.c
  group Device Description
    ./: FlashDev.c
