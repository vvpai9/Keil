# Keil uVision project NUC501_W25Q16.uvproj, settings and files
target NUC501_W25Q16 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: IRAM(0-0x7FFF) CLOCK(80000000) CPUTYPE(ARM7TDMI)
  output: NUC501_W25Q16
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=1
  memory RVCT9: RAM 0x0 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c SPI_Flash.c
  group Device Description
    ./: FlashDev.c
