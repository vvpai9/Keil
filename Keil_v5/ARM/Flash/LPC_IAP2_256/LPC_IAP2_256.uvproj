# Keil uVision project LPC_IAP2_256.uvproj, settings and files
target LPC_IAP2_256 (ARM-ADS)
  device: LPC2136 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC_IAP2_256
  AfterMake: cmd.exe /C copy LPC_IAP2_256.axf ..\LPC_IAP2_256.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: IAP.s FlashPrg.c
  group Device Description
    ./: FlashDev.c
