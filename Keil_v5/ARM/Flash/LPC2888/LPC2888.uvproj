# Keil uVision project LPC2888.uvproj, settings and files
target LPC2888 (ARM-ADS)
  device: LPC2888 NXP (founded by Philips)
  cpu: IRAM(0x400000-0x40FFFF) IROM(0x10400000-0x104FFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2888
  AfterMake: cmd.exe /C copy Out\LPC2888.axf ..\LPC2888.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x10400000 size 0x100000
  memory RVCT9: RAM 0x400000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
