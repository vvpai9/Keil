# Keil uVision project AT91SAM9RL_DF.uvproj, settings and files
target AT91SAM9RL_DF_P1056 (ARM-ADS)
  device: AT91SAM9RL64 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x407FFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: AT91SAM9RL_DF_P1056
  AfterMake: cmd.exe /C copy Out\AT91SAM9RL_DF_P1056.axf ..\AT91SAM9RL_DF_P1056.FLX
  c flags: Optim=4
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c DFlashHW.c
  group Device Description
    ./: FlashDev.c
