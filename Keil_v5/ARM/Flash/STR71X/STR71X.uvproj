# Keil uVision project STR71X.uvproj, settings and files
target STR71X_BANK0 (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: STR71X_B0
  AfterMake: cmd.exe /C copy STR71X_B0.axf ..\STR71X_B0.FLX
  c flags: Optim=3
  c define: FLASH_BANK0
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STR71X_BANK1 (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: as above
  output: STR71X_B1
  AfterMake: cmd.exe /C copy STR71X_B1.axf ..\STR71X_B1.FLX
  c flags: Optim=3
  c define: FLASH_BANK1
  memory RVCT4: ROM 0x40000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
