# Keil uVision project TMS570xxxx.uvproj, settings and files
target TMS570LS20XX (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: IRAM(0x08000000-0x08027FFF) IROM(0-0x001FFFFF) CLOCK(160000000) CPUTYPE("Cortex-R4F") EBIG
  output: TMS570xxxx
  AfterMake: cmd.exe /C copy Output\TMS570xxxx.axf ..\TMS570LS20XX.FLM
  c flags: Optim=3
  c define: TMS570LS20XX, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm define: TMS570LS20XX
  asm misc: --diag_suppress 1608
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: .\Target.lin
  link misc: --be32 --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Flash Library
    ./Flash Library/: pf035a_api_eabi.lib
target TMS570LS10XX (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: as above
  output: TMS570xxxx
  AfterMake: cmd.exe /C copy Output\TMS570xxxx.axf ..\TMS570LS10XX.FLM
  c flags: Optim=3
  c define: TMS570LS10XX, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm define: TMS570LS10XX
  asm misc: --diag_suppress 1608
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: .\Target.lin
  link misc: --be32 --entry 0
target TMS570LS20XXECC (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: as above
  output: TMS570xxxx
  AfterMake: cmd.exe /C copy Output\TMS570xxxx.axf ..\TMS570LS20XXECC.FLM
  c flags: Optim=3
  c define: TMS570LS20XXECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm define: TMS570LS20XXECC
  asm misc: --diag_suppress 1608
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: .\Target.lin
  link misc: --be32 --entry 0
target TMS570LS10XXECC (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: as above
  output: TMS570xxxx
  AfterMake: cmd.exe /C copy Output\TMS570xxxx.axf ..\TMS570LS10XXECC.FLM
  c flags: Optim=3
  c define: TMS570LS10XXECC, F035, __big_endian__
  c misc: --diag_suppress 3017
  asm define: TMS570LS10XXECC
  asm misc: --diag_suppress 1608
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: .\Target.lin
  link misc: --be32 --entry 0
