# Keil uVision project ADuC703x_96K.uvproj, settings and files
target ADuC703x_96K (ARM-ADS)
  device: ADuC7032 Analog Devices
  cpu: IRAM(0x40000-0x417FF) IROM(0x80000-0x97FFF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: ADuC703x_96K
  AfterMake: cmd.exe /C copy ADuC703x_96K.axf ..\ADuC703x_96K.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x80000 size 0x18000
  memory RVCT9: RAM 0x40000 size 0x1800
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: AutoDetectFlash.s FlashPrg.c
  group Device Description
    ./: FlashDev.c
