# Keil uVision project AT29x1024.uvproj, settings and files
target AT29x1024 (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: AT29x1024
  AfterMake: cmd.exe /C copy AT29x1024.axf ..\AT29x1024.FLX
  c flags: Optim=3
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
