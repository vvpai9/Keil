# Keil uVision project RC28F256P30B.uvproj, settings and files
target RC28F256P30B (ARM-ADS)
  device: LPC2210 Philips
  cpu: IRAM(0x40000000-0x40003FFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: RC28F256P30B
  AfterMake: cmd.exe /C copy Output\RC28F256P30B.axf ..\RC28F256P30B.FLX
  c flags: Optim=4
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
