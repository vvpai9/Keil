# Keil uVision project TC58FVM5B2A.uvproj, settings and files
target TC58FVM5B2A (ARM-ADS)
  device: LPC2220 Philips
  cpu: IRAM(0x40000000-0x4000FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: TC58FVM5B2A
  AfterMake: cmd.exe /C copy TC58FVM5B2A.axf ..\TC58FVM5B2A.FLX
  c flags: Optim=2
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
