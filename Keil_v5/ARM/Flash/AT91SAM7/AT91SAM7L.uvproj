# Keil uVision project AT91SAM7L.uvproj, settings and files
target AT91SAM7L (ARM-ADS)
  device: AT91SAM7L128 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x3007FF) IROM(0x100000-0x11FFFF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: AT91SAM7L
  AfterMake: cmd.exe /C copy Out\AT91SAM7L.axf ..\AT91SAM7L.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x800
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
