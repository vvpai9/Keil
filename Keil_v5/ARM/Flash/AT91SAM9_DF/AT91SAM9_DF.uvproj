# Keil uVision project AT91SAM9_DF.uvproj, settings and files
target AT91SAM9_DF_P528_CS0 (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: AT91SAM9_DF_P528_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9_DF_P528_CS0.axf ..\AT91SAM9_DF_P528_CS0.FLX
  c flags: Optim=1
  c define: P528_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x300000 size 0xe00
  memory RVCT9: RAM 0x300e00 size 0x200
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c DFlashHW.c
  group Device Description
    ./: FlashDev.c
target AT91SAM9_DF_P1056_CS0 (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: AT91SAM9_DF_P1056_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9_DF_P1056_CS0.axf ..\AT91SAM9_DF_P1056_CS0.FLX
  c flags: Optim=1
  c define: P1056_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x300000 size 0xe00
  memory RVCT9: RAM 0x300e00 size 0x200
  scatter file: .\Target.lin
  link misc: --entry 0
target AT91SAM9_DF_P1056_CS1 (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: AT91SAM9_DF_P1056_CS1
  AfterMake: cmd.exe /C copy Out\AT91SAM9_DF_P1056_CS1.axf ..\AT91SAM9_DF_P1056_CS1.FLX
  c flags: Optim=1
  c define: P1056_CS1
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x300000 size 0xe00
  memory RVCT9: RAM 0x300e00 size 0x200
  scatter file: .\Target.lin
  link misc: --entry 0
target AT91SAM9G45_DF_P528_CS0 (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: AT91SAM9G45_DF_P528_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9G45_DF_P528_CS0.axf ..\AT91SAM9G45_DF_P528_CS0.FLX
  c flags: Optim=3
  c define: P528_CS0, ATSAM9G45
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target AT91SAM9M10_DF_P528_CS0 (ARM-ADS)
  device: AT91SAM9M10 Atmel
  cpu: as above
  output: AT91SAM9M10_DF_P528_CS0
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=3
  c define: P528_CS0, ATSAM9M10
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
