# Keil uVision project S29GLxxx.uvproj, settings and files
target S29GL016A (ARM-ADS)
  device: LPC2210 Philips
  cpu: IRAM(0x40000000-0x40003FFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: S29GL016
  AfterMake: cmd.exe /C copy Output\S29GL016.axf ..\S29GL016.FLX
  c flags: Optim=4
  c define: S29GL016
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target S29GL032A_N (ARM-ADS)
  device: LPC2210 Philips
  cpu: as above
  output: S29GL032
  AfterMake: cmd.exe /C copy Output\S29GL032.axf ..\S29GL032.FLX
  c flags: Optim=4
  c define: S29GL032
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target S29GL064A_N (ARM-ADS)
  device: LPC2210 Philips
  cpu: as above
  output: S29GL064
  AfterMake: cmd.exe /C copy Output\S29GL064.axf ..\S29GL064.FLX
  c flags: Optim=4
  c define: S29GL064
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target S29GL128P (ARM-ADS)
  device: LPC2210 Philips
  cpu: as above
  output: S29GL128
  AfterMake: cmd.exe /C copy Output\S29GL128.axf ..\S29GL128.FLX
  c flags: Optim=4
  c define: S29GL128
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target S29GL256P (ARM-ADS)
  device: LPC2210 Philips
  cpu: as above
  output: S29GL256
  AfterMake: cmd.exe /C copy Output\S29GL256.axf ..\S29GL256.FLX
  c flags: Optim=4
  c define: S29GL256
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target S29GL512P (ARM-ADS)
  device: LPC2210 Philips
  cpu: as above
  output: S29GL512
  AfterMake: cmd.exe /C copy Output\S29GL512.axf ..\S29GL512.FLX
  c flags: Optim=4
  c define: S29GL512
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target S29GL01GP (ARM-ADS)
  device: LPC2210 Philips
  cpu: as above
  output: S29GL01G
  AfterMake: cmd.exe /C copy Output\S29GL01G.axf ..\S29GL01G.FLX
  c flags: Optim=4
  c define: S29GL01G
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
