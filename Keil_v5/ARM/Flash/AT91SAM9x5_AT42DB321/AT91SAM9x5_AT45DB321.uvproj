# Keil uVision project AT91SAM9x5_AT45DB321.uvproj, settings and files
target SAM9X5_CM_AT42DB321_CS0 (ARM-ADS)
  device: AT91SAM9G35 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x100000-0x10FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: SAM9x5_CM_AT42DB321_CS0
  AfterMake: cmd.exe /C copy Out\SAM9x5_CM_AT42DB321_CS0.axf ..\SAM9x5_CM_AT42DB321_CS0.FLX
  c flags: Optim=1
  c define: P528_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c DFlashHW.c
  group Device Description
    ./: FlashDev.c
