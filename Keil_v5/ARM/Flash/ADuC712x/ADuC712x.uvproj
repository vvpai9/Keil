# Keil uVision project ADuC712x.uvproj, settings and files
target ADuC712x (ARM-ADS)
  device: ADuC7128 Analog Devices
  cpu: IRAM(0x40000-0x41FFF) IROM(0x80000-0x9F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: ADuC712x
  AfterMake: cmd.exe /C copy ADuC712x.axf ..\ADuC712x.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x80000 size 0x1f800
  memory RVCT9: RAM 0x40000 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
