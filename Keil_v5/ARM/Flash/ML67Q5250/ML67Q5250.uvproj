# Keil uVision project ML67Q5250.uvproj, settings and files
target ML67Q5250 (ARM-ADS)
  device: ML67Q5250 OKI
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ML67Q5250
  AfterMake: cmd.exe /C copy ML67Q5250.axf ..\ML67Q5250.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
