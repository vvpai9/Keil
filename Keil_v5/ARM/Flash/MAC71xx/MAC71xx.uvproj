# Keil uVision project MAC71xx.uvproj, settings and files
target MAC71x1 Program Flash (ARM-ADS)
  device: MAC7111 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0x0-0x7FFFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: MAC71x1
  AfterMake: cmd.exe /C copy MAC71x1.axf ..\MAC71x1.FLX
  c flags: Optim=3
  c define: MAC71x1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MAC71x2 Program Flash (ARM-ADS)
  device: MAC7112 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: MAC71x2
  AfterMake: cmd.exe /C copy MAC71x2.axf ..\MAC71x2.FLX
  c flags: Optim=3
  c define: MAC71x2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target MAC71x4 Program Flash (ARM-ADS)
  device: MAC7114 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x40005FFF) IROM(0x0-0x5FFFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: MAC71x4
  AfterMake: cmd.exe /C copy MAC71x4.axf ..\MAC71x4.FLX
  c flags: Optim=3
  c define: MAC71x4
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x40000000 size 0x6000
  scatter file: .\Target.lin
  link misc: --entry 0
target MAC71x5 Program Flash (ARM-ADS)
  device: MAC7115 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x40009FFF) IROM(0x0-0xBFFFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: MAC71x5
  AfterMake: cmd.exe /C copy MAC71x5.axf ..\MAC71x5.FLX
  c flags: Optim=3
  c define: MAC71x5
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x40000000 size 0xa000
  scatter file: .\Target.lin
  link misc: --entry 0
target MAC71x6 Program Flash (ARM-ADS)
  device: MAC7116 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x4000BFFF) IROM(0x0-0xFFFFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: MAC71x6
  AfterMake: cmd.exe /C copy MAC71x6.axf ..\MAC71x6.FLX
  c flags: Optim=3
  c define: MAC71x6
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0xc000
  scatter file: .\Target.lin
  link misc: --entry 0
