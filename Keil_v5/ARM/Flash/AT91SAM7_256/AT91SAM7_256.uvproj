# Keil uVision project AT91SAM7_256.uvproj, settings and files
target AT91SAM7_256 (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: AT91SAM7_256
  AfterMake: cmd.exe /C copy Out\AT91SAM7_256.axf ..\AT91SAM7_256.FLX
  c include: C:\Keil\ARM\INC\Atmel\SAM7S
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
