# Keil uVision project ADuC702x.uvproj, settings and files
target ADuC702x (ARM-ADS)
  device: ADuC7020 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: ADuC702x
  AfterMake: cmd.exe /C copy ADuC702X.axf ..\ADuC702x.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
