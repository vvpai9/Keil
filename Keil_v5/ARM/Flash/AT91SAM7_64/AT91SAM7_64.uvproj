# Keil uVision project AT91SAM7_64.uvproj, settings and files
target AT91SAM7_64 (ARM-ADS)
  device: AT91SAM7S64 Atmel
  cpu: IRAM(0x200000-0x203FFF) IROM(0x100000-0x10FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: AT91SAM7_64
  AfterMake: cmd.exe /C copy Out\AT91SAM7_64.axf ..\AT91SAM7_64.FLX
  c flags: Optim=3
  c include: C:\Keil\ARM\INC\Atmel\SAM7S
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x200000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
