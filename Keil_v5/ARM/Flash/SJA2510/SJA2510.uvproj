# Keil uVision project SJA2510.uvproj, settings and files
target SJA2510 512kB Flash (ARM-ADS)
  device: SJA2510HL/696 NXP (founded by Philips)
  cpu: IRAM(0x80000000-0x80013FFF) IROM(0x20000000-0x200BFFFF) CLOCK(10000000) CPUTYPE(ARM968E-S)
  output: SJA2510_512
  AfterMake: cmd.exe /C copy Output\SJA2510_512.axf ..\SJA2510_512.FLX
  c flags: Optim=3
  c define: SIZE_512kB
  memory RVCT4: ROM 0x20000000 size 0x80000
  memory RVCT9: RAM 0x80000000 size 0x14000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target SJA2510 768kB Flash (ARM-ADS)
  device: SJA2510HL/696 NXP (founded by Philips)
  cpu: as above
  output: SJA2510_768
  AfterMake: cmd.exe /C copy Output\SJA2510_768.axf ..\SJA2510_768.FLX
  c flags: Optim=3
  c define: SIZE_768kB
  memory RVCT4: ROM 0x20000000 size 0xc0000
  memory RVCT9: RAM 0x80000000 size 0x14000
  scatter file: .\Target.lin
  link misc: --entry 0
