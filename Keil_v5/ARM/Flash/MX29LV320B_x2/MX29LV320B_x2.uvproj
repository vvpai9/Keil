# Keil uVision project MX29LV320B_x2.uvproj, settings and files
target MX29LV320B_x2 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: MX29LV320B_x2
  AfterMake: cmd.exe /C copy Out\MX29LV320B_x2.axf ..\MX29LV320B_x2.FLX
  c flags: Optim=4
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
