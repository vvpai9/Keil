# Keil uVision project TMS470R1xxxx.uvproj, settings and files
target TMS470R1A64 Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0xFFFFF) CLOCK(24000000) CPUTYPE(ARM7TDMI) EBIG
  output: TMS470R1A64
  AfterMake: cmd.exe /C copy Output\TMS470R1A64.axf ..\TMS470R1A64.FLX
  c flags: Optim=3
  c define: A64
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Flash API Functions
    ./FlashAPI/: Blank.c Compact.c Erase.c Prog.c Verify.c
  group Flash API Aux Functions
    ./FlashAPI/: feed_dog.c feed_dog_awd_dwd.c init_state.c sector_select.c track_pulses.c
target TMS470R1A128 Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1A128
  AfterMake: cmd.exe /C copy Output\TMS470R1A128.axf ..\TMS470R1A128.FLX
  c flags: Optim=3
  c define: A128
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1A256 Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1A256
  AfterMake: cmd.exe /C copy Output\TMS470R1A256.axf ..\TMS470R1A256.FLX
  c flags: Optim=3
  c define: A256
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1A288 Flash B0 (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1A288_B0
  AfterMake: cmd.exe /C copy Output\TMS470R1A288_B0.axf ..\TMS470R1A288_B0.FLX
  c flags: Optim=3
  c define: A288_BANK0
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1A288 Flash B1 (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1A288_B1
  AfterMake: cmd.exe /C copy Output\TMS470R1A288_B1.axf ..\TMS470R1A288_B1.FLX
  c flags: Optim=3
  c define: A288_BANK1
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1A384 Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1A384
  AfterMake: cmd.exe /C copy Output\TMS470R1A384.axf ..\TMS470R1A384.FLX
  c flags: Optim=3
  c define: A384
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1B512 Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1B512
  AfterMake: cmd.exe /C copy Output\TMS470R1B512.axf ..\TMS470R1B512.FLX
  c flags: Optim=3
  c define: B512
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1B768 Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1B768
  AfterMake: cmd.exe /C copy Output\TMS470R1B768.axf ..\TMS470R1B768.FLX
  c flags: Optim=3
  c define: B768
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
target TMS470R1B1M Flash (ARM-ADS)
  device: TMS470R1B1M TI
  cpu: as above
  output: TMS470R1B1M
  AfterMake: cmd.exe /C copy Output\TMS470R1B1M.axf ..\TMS470R1B1M.FLX
  c flags: Optim=3
  c define: B1M
  c misc: --diag_suppress 3017
  asm misc: --diag_suppress 1608
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --entry 0
