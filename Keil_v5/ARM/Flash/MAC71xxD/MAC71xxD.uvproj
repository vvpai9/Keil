# Keil uVision project MAC71xxD.uvproj, settings and files
target MAC71xx Data Flash (ARM-ADS)
  device: MAC7101 Freescale Semiconductor
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0x0-0x7FFFF) CLOCK(8000000) CPUTYPE(ARM7TDMI) EBIG
  output: MAC71xxD
  AfterMake: cmd.exe /C copy MAC71xxD.axf ..\MAC71xxD.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
