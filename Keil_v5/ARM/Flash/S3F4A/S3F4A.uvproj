# Keil uVision project S3F4A.uvproj, settings and files
target S3F4A_512 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: S3F4A_512
  AfterMake: cmd.exe /C copy Output\S3F4A_512.axf ..\S3F4A_512.FLX
  c flags: Optim=1
  c define: SIZE_512
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x80000000 size 0x80008000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target S3F4A_1024 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: S3F4A_1024
  AfterMake: cmd.exe /C copy Output\S3F4A_1024.axf ..\S3F4A_1024.FLX
  c flags: Optim=1
  c define: SIZE_1024
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x80000000 size 0x80008000
  scatter file: .\Target.lin
  link misc: --entry 0
