# Keil uVision project RC28F320J.uvproj, settings and files
target RC28F320J (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: RC28F320J
  AfterMake: cmd.exe /C copy RC28F320J.axf ..\RC28F320J.FLX
  c flags: Optim=3
  c misc: --diag_suppress 3017
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
