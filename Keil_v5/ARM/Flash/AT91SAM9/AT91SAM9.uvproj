# Keil uVision project AT91SAM9.uvproj, settings and files
target AT91SAM9_128 (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x200000-0x27FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: AT91SAM9_128
  AfterMake: cmd.exe /C copy Out\AT91SAM9_128.axf ..\AT91SAM9_128.FLX
  c flags: Optim=4
  c define: SIZE_128k
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target AT91SAM9_256 (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: AT91SAM9_256
  AfterMake: cmd.exe /C copy Out\AT91SAM9_256.axf ..\AT91SAM9_256.FLX
  c flags: Optim=4
  c define: SIZE_256k
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
target AT91SAM9_512 (ARM-ADS)
  device: AT91SAM9XE512 Atmel
  cpu: as above
  output: AT91SAM9_512
  AfterMake: cmd.exe /C copy Out\AT91SAM9_512.axf ..\AT91SAM9_512.FLX
  c flags: Optim=1
  c define: SIZE_512k
  memory RVCT4: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
