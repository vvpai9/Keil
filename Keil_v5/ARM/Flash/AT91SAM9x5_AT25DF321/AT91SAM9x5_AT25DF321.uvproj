# Keil uVision project AT91SAM9x5_AT25DF321.uvproj, settings and files
target AT91SAM9G15_AT25DF321_CS0 (ARM-ADS)
  device: AT91SAM9G15 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x100000-0x10FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: AT91SAM9x5_AT25DF321_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9x5_AT25DF321_CS0.axf ..\AT91SAM9G15_AT25DF321_CS0.FLX
  c flags: Optim=1
  c define: AT91SAM9G15 P256_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c DFlashHW.c
  group Device Description
    ./: FlashDev.c
target AT91SAM9G35_AT25DF321_CS0 (ARM-ADS)
  device: AT91SAM9G35 Atmel
  cpu: as above
  output: AT91SAM9x5_AT25DF321_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9x5_AT25DF321_CS0.axf ..\AT91SAM9G35_AT25DF321_CS0.FLX
  c flags: Optim=1
  c define: AT91SAM9G35 P256_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
target AT91SAM9X25_AT25DF321_CS0 (ARM-ADS)
  device: AT91SAM9X25 Atmel
  cpu: as above
  output: AT91SAM9x5_AT25DF321_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9x5_AT25DF321_CS0.axf ..\AT91SAM9X25_AT25DF321_CS0.FLX
  c flags: Optim=1
  c define: AT91SAM9X25 P256_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
target SAM9x5_CM_AT25DF321_CS0 (ARM-ADS)
  device: AT91SAM9G35 Atmel
  cpu: as above
  output: AT91SAM9x5_AT25DF321_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9x5_AT25DF321_CS0.axf ..\SAM9x5_CM_AT25DF321_CS0.FLX
  c flags: Optim=1
  c define: SAM9x5_CM P256_CS0
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
