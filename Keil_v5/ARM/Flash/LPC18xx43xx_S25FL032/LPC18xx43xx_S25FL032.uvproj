# Keil uVision project LPC18xx43xx_S25FL032.uvproj, settings and files
target LPC18xx43xx_S25FL032 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPC18xx43xx_S25FL032
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group SPIFI Lib
    ./: spifi_drv_PI.lib
