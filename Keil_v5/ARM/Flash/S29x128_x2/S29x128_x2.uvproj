# Keil uVision project S29x128_x2.uvproj, settings and files
target S29x128_x2 (ARM-ADS)
  device: LPC2210 Philips
  cpu: IRAM(0x40000000-0x40003FFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: S29x128_x2
  AfterMake: cmd.exe /C copy Output\S29x128_x2.axf ..\S29x128_x2.FLX
  c flags: Optim=3
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
