# Keil uVision project AT91SAM7_256_B1.uvproj, settings and files
target AT91SAM7_256_B1 (ARM-ADS)
  device: AT91SAM7SE512 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x17FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: AT91SAM7_256_B1
  AfterMake: cmd.exe /C copy Out\AT91SAM7_256_B1.axf ..\AT91SAM7_256_B1.FLX
  c include: C:\Keil\ARM\INC\Atmel\SAM7SE
  memory RVCT4: ROM 0x100000 size 0x80000
  memory RVCT9: RAM 0x200000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
