# Keil uVision project ADuC706x.uvproj, settings and files
target ADuC706x (ARM-ADS)
  device: ADuC7060 Analog Devices
  cpu: IRAM(0x40000-0x40FFF) IROM(0x80000-0x87FFF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: ADuC706x
  AfterMake: cmd.exe /C copy ADuC706x.axf ..\ADuC706x.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x80000 size 0x8000
  memory RVCT9: RAM 0x40000 size 0x1000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
