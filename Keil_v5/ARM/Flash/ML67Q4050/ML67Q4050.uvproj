# Keil uVision project ML67Q4050.uvproj, settings and files
target ML67Q4050 (ARM-ADS)
  device: ML67Q4050 OKI
  cpu: IRAM(0x10000000-0x10007FFF) IROM(0x08000000-0x0800FFFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: ML67Q4050
  AfterMake: cmd.exe /C copy ML67Q4050.axf ..\ML67Q4050.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
