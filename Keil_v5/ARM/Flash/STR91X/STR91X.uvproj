# Keil uVision project STR91X.uvproj, settings and files
target STR91xFxx2 Bank0 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: STR91xFxx2
  AfterMake: cmd.exe /C copy STR91xFxx2.axf ..\STR91xFxx2.FLX
  c flags: Optim=3
  c define: STR91xFxx2 BANK0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STR91xFxx4 Bank0 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx4
  AfterMake: cmd.exe /C copy STR91xFxx4.axf ..\STR91xFxx4.FLX
  c flags: Optim=3
  c define: STR91xFxx4 BANK0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx6 Bank0 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx6
  AfterMake: cmd.exe /C copy STR91xFxx6.axf ..\STR91xFxx6.FLX
  c flags: Optim=3
  c define: STR91xFxx6 BANK0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx7 Bank0 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx7
  AfterMake: cmd.exe /C copy STR91xFxx7.axf ..\STR91xFxx7.FLX
  c flags: Optim=3
  c define: STR91xFxx7 BANK0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx2 Bank0 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx2
  AfterMake: cmd.exe /C copy STR91xFxx2.axf ..\STR91xFxx2_.FLX
  c flags: Optim=3
  c define: STR91xFxx2 BANK0 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx4 Bank0 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx4
  AfterMake: cmd.exe /C copy STR91xFxx4.axf ..\STR91xFxx4_.FLX
  c flags: Optim=3
  c define: STR91xFxx4 BANK0 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx6 Bank0 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx6
  AfterMake: cmd.exe /C copy STR91xFxx6.axf ..\STR91xFxx6_.FLX
  c flags: Optim=3
  c define: STR91xFxx6 BANK0 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx7 Bank0 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx7
  AfterMake: cmd.exe /C copy STR91xFxx7.axf ..\STR91xFxx7_.FLX
  c flags: Optim=3
  c define: STR91xFxx7 BANK0 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx2 Bank1 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx2B1
  AfterMake: cmd.exe /C copy STR91xFxx2B1.axf ..\STR91xFxx2B1.FLX
  c flags: Optim=3
  c define: STR91xFxx2 BANK1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx4 Bank1 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx4B1
  AfterMake: cmd.exe /C copy STR91xFxx4B1.axf ..\STR91xFxx4B1.FLX
  c flags: Optim=3
  c define: STR91xFxx4 BANK1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx6 Bank1 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx6B1
  AfterMake: cmd.exe /C copy STR91xFxx6B1.axf ..\STR91xFxx6B1.FLX
  c flags: Optim=3
  c define: STR91xFxx6 BANK1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx7 Bank1 (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx7B1
  AfterMake: cmd.exe /C copy STR91xFxx7B1.axf ..\STR91xFxx7B1.FLX
  c flags: Optim=3
  c define: STR91xFxx7 BANK1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR91xFxx2 Bank1 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx2B1
  AfterMake: cmd.exe /C copy STR91xFxx2B1.axf ..\STR91xFxx2B1_.FLX
  c flags: Optim=3
  c define: STR91xFxx2 BANK1 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx4 Bank1 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx4B1
  AfterMake: cmd.exe /C copy STR91xFxx4B1.axf ..\STR91xFxx4B1_.FLX
  c flags: Optim=3
  c define: STR91xFxx4 BANK1 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx6 Bank1 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx6B1
  AfterMake: cmd.exe /C copy STR91xFxx6B1.axf ..\STR91xFxx6B1_.FLX
  c flags: Optim=3
  c define: STR91xFxx6 BANK1 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91xFxx7 Bank1 ICP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xFxx7B1
  AfterMake: cmd.exe /C copy STR91xFxx7B1.axf ..\STR91xFxx7B1_.FLX
  c flags: Optim=3
  c define: STR91xFxx7 BANK1 ICP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91x OTP (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xOTP
  AfterMake: cmd.exe /C copy STR91xOTP.axf ..\STR91xOTP.FLX
  c flags: Optim=3
  c define: OTP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91x User Code (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xUC
  AfterMake: cmd.exe /C copy STR91xUC.axf ..\STR91xUC.FLX
  c flags: Optim=3
  c define: USERCODE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
target STR91x CFG and Security (ARM-ADS)
  device: STR912FW44 STMicroelectronics
  cpu: as above
  output: STR91xCFG
  AfterMake: cmd.exe /C copy STR91xCFG.axf ..\STR91xCFG.FLX
  c flags: Optim=3
  c define: CFG_SECURITY
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\TargetX.lin
  link misc: --diag_suppress 6305
