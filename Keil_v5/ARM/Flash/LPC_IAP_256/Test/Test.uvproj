# Keil uVision project Test.uvproj, settings and files
target Flash Test (ARM-ADS)
  device: LPC2124 Philips
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Test
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  link misc: --first Startup.o(Reset)
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Program Functions
    ../: IAP.s FlashPrg.c
  group Test Code
    ./: Test.c
