# Keil uVision project LPC3000_NAND_SP.uvproj, settings and files
target LPC3000_NAND_SP (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: LPC3000_NAND_SP
  AfterMake: cmd.exe /C copy Output\LPC3000_NAND_SP.axf ..\LPC3000_NAND_SP.FLX
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c FlashHW.c
  group Device Description
    ./: FlashDev.c
