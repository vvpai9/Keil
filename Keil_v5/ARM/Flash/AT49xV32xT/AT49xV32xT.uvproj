# Keil uVision project AT49xV32xT.uvproj, settings and files
target AT49xV32xT (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: AT49xV32xT
  AfterMake: cmd.exe /C copy AT49xV32xT.axf ..\AT49xV32xT.FLX
  c flags: Optim=3
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
