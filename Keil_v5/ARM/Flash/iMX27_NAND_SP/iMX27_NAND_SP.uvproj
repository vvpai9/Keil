# Keil uVision project iMX27_NAND_SP.uvproj, settings and files
target iMX27_NAND_SP (ARM-ADS)
  device: MCIMX27 Freescale Semiconductor
  cpu: IRAM(0xFFFF4C00-0xFFFFFFFF) IROM(0x0-0x3FFF) CLOCK(26000000) CPUTYPE(ARM926EJ-S) EBIG
  output: iMX27_NAND_SP
  AfterMake: cmd.exe /C copy Output\iMX27_NAND_SP.axf ..\iMX27_NAND_SP.FLX
  c flags: Optim=4
  memory RVCT4: ROM 0xffff4c00 size 0x800
  memory RVCT9: RAM 0xffff5c00 size 0x1000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c FlashHW.c
  group Device Description
    ./: FlashDev.c
