# Keil uVision project ML67_512.uvproj, settings and files
target ML67_512 (ARM-ADS)
  device: ML675003 OKI
  cpu: IRAM(0x50000000-0x50007FFF) IROM(0xC8000000-0xC807FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ML67_512
  AfterMake: cmd.exe /C copy ML67_512.axf ..\ML67_512.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT9: RAM 0x50000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
