# Keil uVision project W19B320ABT.uvproj, settings and files
target W19B320ABT (ARM-ADS)
  device: W90P710 Winbond
  cpu: IRAM(0xFFE00000-0xFFE01FFF) IROM(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: W19B320ABT
  AfterMake: cmd.exe /C copy Output\W19B320ABT.axf ..\W19B320ABT.FLX
  c flags: Optim=3
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
