# Keil uVision project ML67Q5260.uvproj, settings and files
target ML67Q5260 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ML67Q5260
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=3
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
