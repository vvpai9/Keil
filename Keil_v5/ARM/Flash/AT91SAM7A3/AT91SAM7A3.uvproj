# Keil uVision project AT91SAM7A3.uvproj, settings and files
target AT91SAM7A3 (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x13FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: AT91SAM7A3
  AfterMake: cmd.exe /C copy Out\AT91SAM7A3.axf ..\AT91SAM7A3.FLX
  c flags: Optim=3
  c include: C:\Keil\ARM\INC\Atmel
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
