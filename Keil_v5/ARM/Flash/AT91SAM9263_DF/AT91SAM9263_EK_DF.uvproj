# Keil uVision project AT91SAM9263_EK_DF.uvproj, settings and files
target AT91SAM9263_DF_P1056_CS0 (ARM-ADS)
  device: AT91SAM9263 Atmel
  cpu: IRAM(0x300000-0x313FFF) IROM(0x400000-0x41FFFF) CLOCK(16367660) CPUTYPE(ARM926EJ-S)
  output: AT91SAM9263_DF_P1056_CS0
  AfterMake: cmd.exe /C copy Out\AT91SAM9263_DF_P1056_CS0.axf ..\AT91SAM9263_DF_P1056_CS0.FLX
  c flags: Optim=1
  c misc: --diag_suppress 61
  memory RVCT4: ROM 0x300000 size 0xe00
  memory RVCT9: RAM 0x300e00 size 0x200
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c DFlashHW.c
  group Device Description
    ./: FlashDev.c
