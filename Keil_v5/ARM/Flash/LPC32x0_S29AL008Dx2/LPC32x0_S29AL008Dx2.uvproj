# Keil uVision project LPC32x0_S29AL008Dx2.uvproj, settings and files
target LPC32x0_S29AL008Dx2 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: LPC32x0_S29AL008Dx2
  AfterMake: cmd.exe /C copy Output\LPC32x0_S29AL008Dx2.axf ..\LPC32x0_S29AL008Dx2.FLX
  c flags: Optim=4
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
