# Keil uVision project LH28F128SPH.uvproj, settings and files
target LH28F128SPH (ARM-ADS)
  device: LPC2210 Philips
  cpu: IRAM(0x40000000-0x40003FFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LH28F128SPH
  AfterMake: cmd.exe /C copy Output\LH28F128SPH.axf ..\LH28F128SPH.FLX
  c flags: Optim=3
  c misc: --diag_suppress 3017
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
