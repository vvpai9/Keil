# Keil uVision project LPC31xx_NAND_LP.uvproj, settings and files
target LPC31xx_NAND_LP (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: LPC31xx_NAND_LP
  AfterMake: cmd.exe /C copy Output\LPC31xx_NAND_LP.axf ..\LPC31xx_NAND_LP.FLX
  c flags: Optim=4
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c FlashHW.c
  group Device Description
    ./: FlashDev.c
