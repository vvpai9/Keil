# Keil uVision project SST39x800A.uvproj, settings and files
target SST39x800A (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: SST39x800A
  AfterMake: cmd.exe /C copy SST39x800A.axf ..\SST39x800A.FLX
  c flags: Optim=3
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
