# Keil uVision project LPC29xx.uvproj, settings and files
target LPC29xx 128kB Flash (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LPC29xx_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=3
  c define: SIZE_128kB
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target LPC29xx 256kB Flash (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LPC29xx_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=3
  c define: SIZE_256kB
  scatter file: .\Target.lin
  link misc: --entry 0
target LPC29xx 512kB Flash (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LPC29xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=3
  c define: SIZE_512kB
  scatter file: .\Target.lin
  link misc: --entry 0
target LPC29xx 768kB Flash (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LPC29xx_768
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLX"
  c flags: Optim=3
  c define: SIZE_768kB
  scatter file: .\Target.lin
  link misc: --entry 0
