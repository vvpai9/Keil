# Keil uVision project AS352x_M25P40.uvproj, settings and files
target AS352x_SPI_M25P40 (ARM-ADS)
  device: AS3525 AustriaMicroSystems
  cpu: IRAM(0x81000000-0x8104FFFF) IROM(0x80000000-0x8001FFFF) CLOCK(24000000) CPUTYPE(ARM922T)
  output: AS352x_M25P40
  AfterMake: cmd.exe /C copy Out\AS352x_M25P40.axf ..\AS352x_M25P40.FLX
  c flags: Optim=4
  c misc: --diag_suppress 177
  c include: $KARM\INC\AMS\AS352x\include
  memory RVCT4: ROM 0x80000000 size 0x20000
  memory RVCT9: RAM 0x81000000 size 0x50000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c M25P40_FlashHW.c
  group Device Description
    ./: FlashDev.c
