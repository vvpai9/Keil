# Keil uVision project STR75X.uvproj, settings and files
target STR75X_BANK0 256kB (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: IROM (0x20000000-0x2003FFFF) IRAM(0x40000000-0x40003FFF) CLOCK(4000000) CPUTYPE(ARM7TDMI)
  output: STR75X_B0
  AfterMake: cmd.exe /C copy STR75X_B0.axf ..\STR75X_B0.FLX
  c flags: Optim=3
  c define: FLASH_BANK0,BS256
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STR75X_BANK0 128kB (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: STR75X_B0_128
  AfterMake: cmd.exe /C copy STR75X_B0_128.axf ..\STR75X_B0_128.FLX
  c flags: Optim=3
  c define: FLASH_BANK0,BS128
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR75X_BANK0 64kB (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: STR75X_B0_64
  AfterMake: cmd.exe /C copy STR75X_B0_64.axf ..\STR75X_B0_64.FLX
  c flags: Optim=3
  c define: FLASH_BANK0,BS64
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
target STR75X_BANK1 (ARM-ADS)
  device: STR750FL2 STMicroelectronics
  cpu: as above
  output: STR75X_B1
  AfterMake: cmd.exe /C copy STR75X_B1.axf ..\STR75X_B1.FLX
  c flags: Optim=3
  c define: FLASH_BANK1
  memory RVCT4: ROM 0x20000000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
