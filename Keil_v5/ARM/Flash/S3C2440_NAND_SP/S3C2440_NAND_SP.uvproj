# Keil uVision project S3C2440_NAND_SP.uvproj, settings and files
target S3C2440_NAND_SP (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: S3C2440_NAND_SP
  AfterMake: cmd.exe /C copy Output\S3C2440_NAND_SP.axf ..\S3C2440_NAND_SP.FLX
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0xb00
  memory RVCT9: RAM 0x40000e00 size 0x500
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c FlashHW.c
  group Device Description
    ./: FlashDev.c
