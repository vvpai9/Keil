# Keil uVision project ML69_512.uvproj, settings and files
target ML69_512 (ARM-ADS)
  device: ML69Q6203 OKI
  cpu: IRAM(0x50000000-0x5001FFFF) IROM(0xC8000000-0xC807FFFF) CLOCK(60000000) CPUTYPE(ARM946E-S)
  output: ML69_512
  AfterMake: cmd.exe /C copy ML69_512.axf ..\ML69_512.FLX
  c flags: Optim=3
  memory RVCT4: ROM 0xc8000000 size 0x80000
  memory RVCT9: RAM 0x50000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
