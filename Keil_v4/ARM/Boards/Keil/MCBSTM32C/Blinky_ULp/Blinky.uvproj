# Keil uVision project Blinky.uvproj, settings and files
target SWO Trace (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c include: $K\ARM\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System Files
    ./: startup_stm32f10x_cl.s system_stm32f10x_cl.c core_cm3.c
  group Source Files
    ./: Blinky.c IRQ.c Serial.c Retarget.c
  group Trace Configuration
    ./: STM32_SWO.ini STM32_TP.ini
  group Documentation
    ./: Abstract.txt
target TracePort Trace (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: $K\ARM\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target TracePort InstructionTrace (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: $K\ARM\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
