# Keil uVision project ExtRAM.uvproj, settings and files
target ExtRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ExtRAM
  c flags: Optim=1
  c define: RUN_FROM_FLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./src/cmsis/: startup_stm32f10x.s
  group System
    ./src/cmsis/: system_stm32.c core_cm3.c
    ./src/: retarget.c
  group Source
    ./src/: main.c ext_sram.c
  group Documentation
    ./: Abstract.txt
target Run from ExtRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: ExtRAM
  c flags: Optim=1
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
