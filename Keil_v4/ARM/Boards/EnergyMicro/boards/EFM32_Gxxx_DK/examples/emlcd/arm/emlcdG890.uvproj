# Keil uVision project emlcdG890.uvproj, settings and files
target EmLCD (ARM-ADS)
  device: EFM32G890F128 Energymicro
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: emlcdG890
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\CM3\CoreSupport;..\..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32;..\..\..\bsp
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
    ../../../../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/startup/arm/: startup_efm32.s
  group BSP
    ../../../bsp/: dvk_boardcontrol.c dvk_ebi.c dvk_spi.c dvk.c
  group SourceFiles
    ../: emlcd.c rtc.c energymodes.c lcdcontroller.c lcdtest.c
